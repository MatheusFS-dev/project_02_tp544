# Ansys Electronics Desktop project, version 2025.2
project datasets:
  $eps_Au: (150000000000000, -186.00089) (160000000000000, -163.14213) (170000000000000, -144.11224) (180000000000000, -128.10314) (190000000000000, -114.50826) (200000000000000, -102.86532) (210000000000000, -92.81718) (220000000000000, -84.084412) (230000000000000, -76.445944) (240000000000000, -69.725036) (250000000000000, -63.779041) (260000000000000, -58.491818) (270000000000000, -53.768037) (280000000000000, -49.528859) (290000000000000, -45.70863) (300000000000000, -42.252313) (310000000000000, -39.113494) (320000000000000, -36.252806) (330000000000000, -33.636677) (340000000000000, -31.236338) (350000000000000, -29.027017) (360000000000000, -26.987294) (370000000000000, -25.098569) (380000000000000, -23.344637) (390000000000000, -21.711335) (400000000000000, -20.186253) (410000000000000, -18.7585) (420000000000000, -17.418507) (430000000000000, -16.15788) (440000000000000, -14.969269) (450000000000000, -13.846276) (460000000000000, -12.78338) (470000000000000, -11.775891) (480000000000000, -10.819917) (490000000000000, -9.9123481) (500000000000000, -9.0508547) (510000000000000, -8.2338938) (520000000000000, -7.4607121) (530000000000000, -6.7313416) (540000000000000, -6.0465702) (550000000000000, -5.4078747) (560000000000000, -4.8172964) (570000000000000, -4.2772451) (580000000000000, -3.7902218) (590000000000000, -3.3584655) (600000000000000, -2.9835452) (610000000000000, -2.6659436) (620000000000000, -2.4046951) (630000000000000, -2.197152) (640000000000000, -2.0389375) (650000000000000, -1.9241177) (660000000000000, -1.8455774) (670000000000000, -1.7955412) (680000000000000, -1.7661513) (690000000000000, -1.7500089) (700000000000000, -1.7406041)
  $sig_Au: (150000000000000, 218667.41) (160000000000000, 192168.71) (170000000000000, 170065.67) (180000000000000, 151429.97) (190000000000000, 135565.31) (200000000000000, 121941.52) (210000000000000, 110149.55) (220000000000000, 99870.051) (230000000000000, 90851.031) (240000000000000, 82891.837) (250000000000000, 75831.402) (260000000000000, 69539.575) (270000000000000, 63910.635) (280000000000000, 58858.395) (290000000000000, 54312.48) (300000000000000, 50215.478) (310000000000000, 46520.747) (320000000000000, 43190.739) (330000000000000, 40195.708) (340000000000000, 37512.733) (350000000000000, 35124.989) (360000000000000, 33021.22) (370000000000000, 31195.388) (380000000000000, 29646.453) (390000000000000, 28378.283) (400000000000000, 27399.666) (410000000000000, 26724.406) (420000000000000, 26371.488) (430000000000000, 26365.297) (440000000000000, 26735.841) (450000000000000, 27518.962) (460000000000000, 28756.467) (470000000000000, 30496.106) (480000000000000, 32791.287) (490000000000000, 35700.421) (500000000000000, 39285.697) (510000000000000, 43611.125) (520000000000000, 48739.62) (530000000000000, 54728.934) (540000000000000, 61626.312) (550000000000000, 69461.861) (560000000000000, 78240.9) (570000000000000, 87935.844) (580000000000000, 98478.642) (590000000000000, 109755.15) (600000000000000, 121603.12) (610000000000000, 133815.27) (620000000000000, 146148.59) (630000000000000, 158339.66) (640000000000000, 170124.49) (650000000000000, 181260.31) (660000000000000, 191545.59) (670000000000000, 200835.19) (680000000000000, 209048.35) (690000000000000, 216168.82) (700000000000000, 222238.31)
materials:
  vacuum: permittivity=1
  Au_JC: permittivity="pwl($eps_Au, Freq)" permeability=1 conductivity="pwl($sig_Au, Freq)"
surface materials:
  Steel-oxidised-surface

design G0084_disco (HFSS, HFSS Modal Network, model units um)
variables:
  theta_inc = 0deg
geometry:
  Au_disco [Au_JC] = cylinder(axis=Z, base_centre=(0um, 0um, 0um), radius=0.033um, height=0.03um)
  Air_Domain [vacuum] = box(corner=(-0.16um, -0.16um, -1um), size=(0.32um, 0.32um, 2.03um))
  Au_disco_1 = Au_disco.copy()
  Air_Domain.subtract(Au_disco_1)
boundaries and excitations:
  LatticePair_Q0PWBS: Lattice Pair Faces=Air_Domain.face(-x, +x) CoordSysVector{(-0.16, -0.16, -1) -> (-0.16, -0.16, 1.03)} PhaseDelay=UseScanAngle Phi=0deg Theta=theta_inc
  LatticePair_OYQ5O1: Lattice Pair Faces=Air_Domain.face(-y, +y) CoordSysVector{(0.16, -0.16, -1) -> (0.16, -0.16, 1.03)} PhaseDelay=UseScanAngle Phi=0deg Theta=theta_inc
  FloquetCima: Floquet Port Faces=Air_Domain.face(+z) NumModes=4 Modes{Mode1{CharImp=Zpi} Mode2{CharImp=Zpi} Mode3{CharImp=Zpi} Mode4{CharImp=Zpi}} PhaseDelay=UseScanAngle Phi=0deg Theta=theta_inc LatticeAVector{(-0.16, -0.16, 1.03) -> (0.16, -0.16, 1.03)} LatticeBVector{(-0.16, -0.16, 1.03) -> (-0.16, 0.16, 1.03)} ModesCalculator{Frequency=1GHz PhiStart=0deg PhiStop=0deg PhiStep=0deg ThetaStart=0deg ThetaStop=0deg ThetaStep=0deg} ModesList{Mode{ModeNumber=1 IndexM=0 IndexN=0 KC2=0 PropagationState=Undefined Attenuation=0 PolarizationState=TE AffectsRefinement} Mode{ModeNumber=2 IndexM=0 IndexN=0 KC2=0 PropagationState=Undefined Attenuation=0 PolarizationState=TM AffectsRefinement} Mode{ModeNumber=3 IndexM=-1 IndexN=0 KC2=385531421917553 PropagationState=Undefined Attenuation=1.7054704e+08 PolarizationState=TE AffectsRefinement} Mode{ModeNumber=4 IndexM=0 IndexN=-1 KC2=385531421917553 PropagationState=Undefined Attenuation=1.7054704e+08 PolarizationState=TE AffectsRefinement}}
  FloquetBaixo: Floquet Port Faces=Air_Domain.face(-z) NumModes=4 Modes{Mode1{CharImp=Zpi} Mode2{CharImp=Zpi} Mode3{CharImp=Zpi} Mode4{CharImp=Zpi}} PhaseDelay=UseScanAngle Phi=0deg Theta=theta_inc LatticeAVector{(-0.16, -0.16, -1) -> (0.16, -0.16, -1)} LatticeBVector{(-0.16, -0.16, -1) -> (-0.16, 0.16, -1)} ModesCalculator{Frequency=1GHz PhiStart=0deg PhiStop=0deg PhiStep=0deg ThetaStart=0deg ThetaStop=0deg ThetaStep=0deg} ModesList{Mode{ModeNumber=1 IndexM=0 IndexN=0 KC2=0 PropagationState=Undefined Attenuation=0 PolarizationState=TE AffectsRefinement} Mode{ModeNumber=2 IndexM=0 IndexN=0 KC2=0 PropagationState=Undefined Attenuation=0 PolarizationState=TM AffectsRefinement} Mode{ModeNumber=3 IndexM=-1 IndexN=0 KC2=385531421917553 PropagationState=Undefined Attenuation=1.7054704e+08 PolarizationState=TE AffectsRefinement} Mode{ModeNumber=4 IndexM=0 IndexN=-1 KC2=385531421917553 PropagationState=Undefined Attenuation=1.7054704e+08 PolarizationState=TE AffectsRefinement}}
setups:
  Setup1: HfssDriven Frequency=666.2THz MaxDeltaS=0.01 MaximumPasses=15 MinimumPasses=1 MinimumConvergedPasses=1 PercentRefinement=30 BasisOrder=1 PortAccuracy=2 DrivenSolverType="Direct Solver"
    sweep Varredura: 187.4THz to 666.2THz, 401 points; Type=Interpolating InterpTolerance=0.5 InterpMaxSolns=250 PassivityErrorTolerance=0.0001
source amplitudes:
  FloquetCima:1: 1W 0deg
  FloquetCima:2, FloquetCima:3, FloquetCima:4, FloquetBaixo:1..FloquetBaixo:4: 0W 0deg

design G0013_disco (HFSS, HFSS Modal Network, model units um)
variables:
  theta_inc = 0deg
geometry:
  Au_disco [Au_JC] = cylinder(axis=Z, base_centre=(0um, 0um, 0um), radius=0.09um, height=0.03um)
  Air_Domain [vacuum] = box(corner=(-0.16um, -0.16um, -1um), size=(0.32um, 0.32um, 2.03um))
  Au_disco_1 = Au_disco.copy()
  Air_Domain.subtract(Au_disco_1)
boundaries and excitations:
  LatticePair_BMB4CD: Lattice Pair Faces=Air_Domain.face(-x, +x) CoordSysVector{(-0.16, -0.16, -1) -> (-0.16, -0.16, 1.03)} PhaseDelay=UseScanAngle Phi=0deg Theta=theta_inc
  LatticePair_OY8D0A: Lattice Pair Faces=Air_Domain.face(-y, +y) CoordSysVector{(0.16, -0.16, -1) -> (0.16, -0.16, 1.03)} PhaseDelay=UseScanAngle Phi=0deg Theta=theta_inc
  FloquetCima: Floquet Port Faces=Air_Domain.face(+z) NumModes=4 Modes{Mode1{CharImp=Zpi} Mode2{CharImp=Zpi} Mode3{CharImp=Zpi} Mode4{CharImp=Zpi}} PhaseDelay=UseScanAngle Phi=0deg Theta=theta_inc LatticeAVector{(-0.16, -0.16, 1.03) -> (0.16, -0.16, 1.03)} LatticeBVector{(-0.16, -0.16, 1.03) -> (-0.16, 0.16, 1.03)} ModesCalculator{Frequency=1GHz PhiStart=0deg PhiStop=0deg PhiStep=0deg ThetaStart=0deg ThetaStop=0deg ThetaStep=0deg} ModesList{Mode{ModeNumber=1 IndexM=0 IndexN=0 KC2=0 PropagationState=Undefined Attenuation=0 PolarizationState=TE AffectsRefinement} Mode{ModeNumber=2 IndexM=0 IndexN=0 KC2=0 PropagationState=Undefined Attenuation=0 PolarizationState=TM AffectsRefinement} Mode{ModeNumber=3 IndexM=-1 IndexN=0 KC2=385531421917553 PropagationState=Undefined Attenuation=1.7054704e+08 PolarizationState=TE AffectsRefinement} Mode{ModeNumber=4 IndexM=0 IndexN=-1 KC2=385531421917553 PropagationState=Undefined Attenuation=1.7054704e+08 PolarizationState=TE AffectsRefinement}}
  FloquetBaixo: Floquet Port Faces=Air_Domain.face(-z) NumModes=4 Modes{Mode1{CharImp=Zpi} Mode2{CharImp=Zpi} Mode3{CharImp=Zpi} Mode4{CharImp=Zpi}} PhaseDelay=UseScanAngle Phi=0deg Theta=theta_inc LatticeAVector{(-0.16, -0.16, -1) -> (0.16, -0.16, -1)} LatticeBVector{(-0.16, -0.16, -1) -> (-0.16, 0.16, -1)} ModesCalculator{Frequency=1GHz PhiStart=0deg PhiStop=0deg PhiStep=0deg ThetaStart=0deg ThetaStop=0deg ThetaStep=0deg} ModesList{Mode{ModeNumber=1 IndexM=0 IndexN=0 KC2=0 PropagationState=Undefined Attenuation=0 PolarizationState=TE AffectsRefinement} Mode{ModeNumber=2 IndexM=0 IndexN=0 KC2=0 PropagationState=Undefined Attenuation=0 PolarizationState=TM AffectsRefinement} Mode{ModeNumber=3 IndexM=-1 IndexN=0 KC2=385531421917553 PropagationState=Undefined Attenuation=1.7054704e+08 PolarizationState=TE AffectsRefinement} Mode{ModeNumber=4 IndexM=0 IndexN=-1 KC2=385531421917553 PropagationState=Undefined Attenuation=1.7054704e+08 PolarizationState=TE AffectsRefinement}}
setups:
  Setup1: HfssDriven Frequency=666.2THz MaxDeltaS=0.01 MaximumPasses=15 MinimumPasses=1 MinimumConvergedPasses=1 PercentRefinement=30 BasisOrder=1 PortAccuracy=2 DrivenSolverType="Direct Solver"
    sweep Varredura: 187.4THz to 666.2THz, 401 points; Type=Interpolating InterpTolerance=0.5 InterpMaxSolns=250 PassivityErrorTolerance=0.0001
source amplitudes:
  FloquetCima:1: 1W 0deg
  FloquetCima:2, FloquetCima:3, FloquetCima:4, FloquetBaixo:1..FloquetBaixo:4: 0W 0deg

design G0066_disco (HFSS, HFSS Modal Network, model units um)
variables:
  theta_inc = 0deg
geometry:
  Au_disco [Au_JC] = cylinder(axis=Z, base_centre=(0um, 0um, 0um), radius=0.048um, height=0.03um)
  Air_Domain [vacuum] = box(corner=(-0.16um, -0.16um, -1um), size=(0.32um, 0.32um, 2.03um))
  Au_disco_1 = Au_disco.copy()
  Air_Domain.subtract(Au_disco_1)
boundaries and excitations:
  LatticePair_8WDLBW: Lattice Pair Faces=Air_Domain.face(-x, +x) CoordSysVector{(-0.16, -0.16, -1) -> (-0.16, -0.16, 1.03)} PhaseDelay=UseScanAngle Phi=0deg Theta=theta_inc
  LatticePair_0ZHS3Y: Lattice Pair Faces=Air_Domain.face(-y, +y) CoordSysVector{(0.16, -0.16, -1) -> (0.16, -0.16, 1.03)} PhaseDelay=UseScanAngle Phi=0deg Theta=theta_inc
  FloquetCima: Floquet Port Faces=Air_Domain.face(+z) NumModes=4 Modes{Mode1{CharImp=Zpi} Mode2{CharImp=Zpi} Mode3{CharImp=Zpi} Mode4{CharImp=Zpi}} PhaseDelay=UseScanAngle Phi=0deg Theta=theta_inc LatticeAVector{(-0.16, -0.16, 1.03) -> (0.16, -0.16, 1.03)} LatticeBVector{(-0.16, -0.16, 1.03) -> (-0.16, 0.16, 1.03)} ModesCalculator{Frequency=1GHz PhiStart=0deg PhiStop=0deg PhiStep=0deg ThetaStart=0deg ThetaStop=0deg ThetaStep=0deg} ModesList{Mode{ModeNumber=1 IndexM=0 IndexN=0 KC2=0 PropagationState=Undefined Attenuation=0 PolarizationState=TE AffectsRefinement} Mode{ModeNumber=2 IndexM=0 IndexN=0 KC2=0 PropagationState=Undefined Attenuation=0 PolarizationState=TM AffectsRefinement} Mode{ModeNumber=3 IndexM=-1 IndexN=0 KC2=385531421917553 PropagationState=Undefined Attenuation=1.7054704e+08 PolarizationState=TE AffectsRefinement} Mode{ModeNumber=4 IndexM=0 IndexN=-1 KC2=385531421917553 PropagationState=Undefined Attenuation=1.7054704e+08 PolarizationState=TE AffectsRefinement}}
  FloquetBaixo: Floquet Port Faces=Air_Domain.face(-z) NumModes=4 Modes{Mode1{CharImp=Zpi} Mode2{CharImp=Zpi} Mode3{CharImp=Zpi} Mode4{CharImp=Zpi}} PhaseDelay=UseScanAngle Phi=0deg Theta=theta_inc LatticeAVector{(-0.16, -0.16, -1) -> (0.16, -0.16, -1)} LatticeBVector{(-0.16, -0.16, -1) -> (-0.16, 0.16, -1)} ModesCalculator{Frequency=1GHz PhiStart=0deg PhiStop=0deg PhiStep=0deg ThetaStart=0deg ThetaStop=0deg ThetaStep=0deg} ModesList{Mode{ModeNumber=1 IndexM=0 IndexN=0 KC2=0 PropagationState=Undefined Attenuation=0 PolarizationState=TE AffectsRefinement} Mode{ModeNumber=2 IndexM=0 IndexN=0 KC2=0 PropagationState=Undefined Attenuation=0 PolarizationState=TM AffectsRefinement} Mode{ModeNumber=3 IndexM=-1 IndexN=0 KC2=385531421917553 PropagationState=Undefined Attenuation=1.7054704e+08 PolarizationState=TE AffectsRefinement} Mode{ModeNumber=4 IndexM=0 IndexN=-1 KC2=385531421917553 PropagationState=Undefined Attenuation=1.7054704e+08 PolarizationState=TE AffectsRefinement}}
setups:
  Setup1: HfssDriven Frequency=666.2THz MaxDeltaS=0.01 MaximumPasses=15 MinimumPasses=1 MinimumConvergedPasses=1 PercentRefinement=30 BasisOrder=1 PortAccuracy=2 DrivenSolverType="Direct Solver"
    sweep Varredura: 187.4THz to 666.2THz, 401 points; Type=Interpolating InterpTolerance=0.5 InterpMaxSolns=250 PassivityErrorTolerance=0.0001
source amplitudes:
  FloquetCima:1: 1W 0deg
  FloquetCima:2, FloquetCima:3, FloquetCima:4, FloquetBaixo:1..FloquetBaixo:4: 0W 0deg

design G0039_disco (HFSS, HFSS Modal Network, model units um)
variables:
  theta_inc = 0deg
geometry:
  Au_disco [Au_JC] = cylinder(axis=Z, base_centre=(0um, 0um, 0um), radius=0.087um, height=0.03um)
  Air_Domain [vacuum] = box(corner=(-0.16um, -0.16um, -1um), size=(0.32um, 0.32um, 2.03um))
  Au_disco_1 = Au_disco.copy()
  Air_Domain.subtract(Au_disco_1)
boundaries and excitations:
  LatticePair_K1D2O1: Lattice Pair Faces=Air_Domain.face(-x, +x) CoordSysVector{(-0.16, -0.16, -1) -> (-0.16, -0.16, 1.03)} PhaseDelay=UseScanAngle Phi=0deg Theta=theta_inc
  LatticePair_JHO27E: Lattice Pair Faces=Air_Domain.face(-y, +y) CoordSysVector{(0.16, -0.16, -1) -> (0.16, -0.16, 1.03)} PhaseDelay=UseScanAngle Phi=0deg Theta=theta_inc
  FloquetCima: Floquet Port Faces=Air_Domain.face(+z) NumModes=4 Modes{Mode1{CharImp=Zpi} Mode2{CharImp=Zpi} Mode3{CharImp=Zpi} Mode4{CharImp=Zpi}} PhaseDelay=UseScanAngle Phi=0deg Theta=theta_inc LatticeAVector{(-0.16, -0.16, 1.03) -> (0.16, -0.16, 1.03)} LatticeBVector{(-0.16, -0.16, 1.03) -> (-0.16, 0.16, 1.03)} ModesCalculator{Frequency=1GHz PhiStart=0deg PhiStop=0deg PhiStep=0deg ThetaStart=0deg ThetaStop=0deg ThetaStep=0deg} ModesList{Mode{ModeNumber=1 IndexM=0 IndexN=0 KC2=0 PropagationState=Undefined Attenuation=0 PolarizationState=TE AffectsRefinement} Mode{ModeNumber=2 IndexM=0 IndexN=0 KC2=0 PropagationState=Undefined Attenuation=0 PolarizationState=TM AffectsRefinement} Mode{ModeNumber=3 IndexM=-1 IndexN=0 KC2=385531421917553 PropagationState=Undefined Attenuation=1.7054704e+08 PolarizationState=TE AffectsRefinement} Mode{ModeNumber=4 IndexM=0 IndexN=-1 KC2=385531421917553 PropagationState=Undefined Attenuation=1.7054704e+08 PolarizationState=TE AffectsRefinement}}
  FloquetBaixo: Floquet Port Faces=Air_Domain.face(-z) NumModes=4 Modes{Mode1{CharImp=Zpi} Mode2{CharImp=Zpi} Mode3{CharImp=Zpi} Mode4{CharImp=Zpi}} PhaseDelay=UseScanAngle Phi=0deg Theta=theta_inc LatticeAVector{(-0.16, -0.16, -1) -> (0.16, -0.16, -1)} LatticeBVector{(-0.16, -0.16, -1) -> (-0.16, 0.16, -1)} ModesCalculator{Frequency=1GHz PhiStart=0deg PhiStop=0deg PhiStep=0deg ThetaStart=0deg ThetaStop=0deg ThetaStep=0deg} ModesList{Mode{ModeNumber=1 IndexM=0 IndexN=0 KC2=0 PropagationState=Undefined Attenuation=0 PolarizationState=TE AffectsRefinement} Mode{ModeNumber=2 IndexM=0 IndexN=0 KC2=0 PropagationState=Undefined Attenuation=0 PolarizationState=TM AffectsRefinement} Mode{ModeNumber=3 IndexM=-1 IndexN=0 KC2=385531421917553 PropagationState=Undefined Attenuation=1.7054704e+08 PolarizationState=TE AffectsRefinement} Mode{ModeNumber=4 IndexM=0 IndexN=-1 KC2=385531421917553 PropagationState=Undefined Attenuation=1.7054704e+08 PolarizationState=TE AffectsRefinement}}
setups:
  Setup1: HfssDriven Frequency=666.2THz MaxDeltaS=0.01 MaximumPasses=15 MinimumPasses=1 MinimumConvergedPasses=1 PercentRefinement=30 BasisOrder=1 PortAccuracy=2 DrivenSolverType="Direct Solver"
    sweep Varredura: 187.4THz to 666.2THz, 401 points; Type=Interpolating InterpTolerance=0.5 InterpMaxSolns=250 PassivityErrorTolerance=0.0001
source amplitudes:
  FloquetCima:1: 1W 0deg
  FloquetCima:2, FloquetCima:3, FloquetCima:4, FloquetBaixo:1..FloquetBaixo:4: 0W 0deg

design G0011_disco (HFSS, HFSS Modal Network, model units um)
variables:
  theta_inc = 0deg
geometry:
  Au_disco [Au_JC] = cylinder(axis=Z, base_centre=(0um, 0um, 0um), radius=0.088um, height=0.03um)
  Air_Domain [vacuum] = box(corner=(-0.16um, -0.16um, -1um), size=(0.32um, 0.32um, 2.03um))
  Au_disco_1 = Au_disco.copy()
  Air_Domain.subtract(Au_disco_1)
boundaries and excitations:
  LatticePair_80Z9P2: Lattice Pair Faces=Air_Domain.face(-x, +x) CoordSysVector{(-0.16, -0.16, -1) -> (-0.16, -0.16, 1.03)} PhaseDelay=UseScanAngle Phi=0deg Theta=theta_inc
  LatticePair_ZP1IMD: Lattice Pair Faces=Air_Domain.face(-y, +y) CoordSysVector{(0.16, -0.16, -1) -> (0.16, -0.16, 1.03)} PhaseDelay=UseScanAngle Phi=0deg Theta=theta_inc
  FloquetCima: Floquet Port Faces=Air_Domain.face(+z) NumModes=4 Modes{Mode1{CharImp=Zpi} Mode2{CharImp=Zpi} Mode3{CharImp=Zpi} Mode4{CharImp=Zpi}} PhaseDelay=UseScanAngle Phi=0deg Theta=theta_inc LatticeAVector{(-0.16, -0.16, 1.03) -> (0.16, -0.16, 1.03)} LatticeBVector{(-0.16, -0.16, 1.03) -> (-0.16, 0.16, 1.03)} ModesCalculator{Frequency=1GHz PhiStart=0deg PhiStop=0deg PhiStep=0deg ThetaStart=0deg ThetaStop=0deg ThetaStep=0deg} ModesList{Mode{ModeNumber=1 IndexM=0 IndexN=0 KC2=0 PropagationState=Undefined Attenuation=0 PolarizationState=TE AffectsRefinement} Mode{ModeNumber=2 IndexM=0 IndexN=0 KC2=0 PropagationState=Undefined Attenuation=0 PolarizationState=TM AffectsRefinement} Mode{ModeNumber=3 IndexM=-1 IndexN=0 KC2=385531421917553 PropagationState=Undefined Attenuation=1.7054704e+08 PolarizationState=TE AffectsRefinement} Mode{ModeNumber=4 IndexM=0 IndexN=-1 KC2=385531421917553 PropagationState=Undefined Attenuation=1.7054704e+08 PolarizationState=TE AffectsRefinement}}
  FloquetBaixo: Floquet Port Faces=Air_Domain.face(-z) NumModes=4 Modes{Mode1{CharImp=Zpi} Mode2{CharImp=Zpi} Mode3{CharImp=Zpi} Mode4{CharImp=Zpi}} PhaseDelay=UseScanAngle Phi=0deg Theta=theta_inc LatticeAVector{(-0.16, -0.16, -1) -> (0.16, -0.16, -1)} LatticeBVector{(-0.16, -0.16, -1) -> (-0.16, 0.16, -1)} ModesCalculator{Frequency=1GHz PhiStart=0deg PhiStop=0deg PhiStep=0deg ThetaStart=0deg ThetaStop=0deg ThetaStep=0deg} ModesList{Mode{ModeNumber=1 IndexM=0 IndexN=0 KC2=0 PropagationState=Undefined Attenuation=0 PolarizationState=TE AffectsRefinement} Mode{ModeNumber=2 IndexM=0 IndexN=0 KC2=0 PropagationState=Undefined Attenuation=0 PolarizationState=TM AffectsRefinement} Mode{ModeNumber=3 IndexM=-1 IndexN=0 KC2=385531421917553 PropagationState=Undefined Attenuation=1.7054704e+08 PolarizationState=TE AffectsRefinement} Mode{ModeNumber=4 IndexM=0 IndexN=-1 KC2=385531421917553 PropagationState=Undefined Attenuation=1.7054704e+08 PolarizationState=TE AffectsRefinement}}
setups:
  Setup1: HfssDriven Frequency=666.2THz MaxDeltaS=0.01 MaximumPasses=15 MinimumPasses=1 MinimumConvergedPasses=1 PercentRefinement=30 BasisOrder=1 PortAccuracy=2 DrivenSolverType="Direct Solver"
    sweep Varredura: 187.4THz to 666.2THz, 401 points; Type=Interpolating InterpTolerance=0.5 InterpMaxSolns=250 PassivityErrorTolerance=0.0001
source amplitudes:
  FloquetCima:1: 1W 0deg
  FloquetCima:2, FloquetCima:3, FloquetCima:4, FloquetBaixo:1..FloquetBaixo:4: 0W 0deg

design G0072_disco (HFSS, HFSS Modal Network, model units um)
variables:
  theta_inc = 0deg
geometry:
  Au_disco [Au_JC] = cylinder(axis=Z, base_centre=(0um, 0um, 0um), radius=0.109um, height=0.03um)
  Air_Domain [vacuum] = box(corner=(-0.16um, -0.16um, -1um), size=(0.32um, 0.32um, 2.03um))
  Au_disco_1 = Au_disco.copy()
  Air_Domain.subtract(Au_disco_1)
boundaries and excitations:
  LatticePair_IS97L0: Lattice Pair Faces=Air_Domain.face(-x, +x) CoordSysVector{(-0.16, -0.16, -1) -> (-0.16, -0.16, 1.03)} PhaseDelay=UseScanAngle Phi=0deg Theta=theta_inc
  LatticePair_WPVOVN: Lattice Pair Faces=Air_Domain.face(-y, +y) CoordSysVector{(0.16, -0.16, -1) -> (0.16, -0.16, 1.03)} PhaseDelay=UseScanAngle Phi=0deg Theta=theta_inc
  FloquetCima: Floquet Port Faces=Air_Domain.face(+z) NumModes=4 Modes{Mode1{CharImp=Zpi} Mode2{CharImp=Zpi} Mode3{CharImp=Zpi} Mode4{CharImp=Zpi}} PhaseDelay=UseScanAngle Phi=0deg Theta=theta_inc LatticeAVector{(-0.16, -0.16, 1.03) -> (0.16, -0.16, 1.03)} LatticeBVector{(-0.16, -0.16, 1.03) -> (-0.16, 0.16, 1.03)} ModesCalculator{Frequency=1GHz PhiStart=0deg PhiStop=0deg PhiStep=0deg ThetaStart=0deg ThetaStop=0deg ThetaStep=0deg} ModesList{Mode{ModeNumber=1 IndexM=0 IndexN=0 KC2=0 PropagationState=Undefined Attenuation=0 PolarizationState=TE AffectsRefinement} Mode{ModeNumber=2 IndexM=0 IndexN=0 KC2=0 PropagationState=Undefined Attenuation=0 PolarizationState=TM AffectsRefinement} Mode{ModeNumber=3 IndexM=-1 IndexN=0 KC2=385531421917553 PropagationState=Undefined Attenuation=1.7054704e+08 PolarizationState=TE AffectsRefinement} Mode{ModeNumber=4 IndexM=0 IndexN=-1 KC2=385531421917553 PropagationState=Undefined Attenuation=1.7054704e+08 PolarizationState=TE AffectsRefinement}}
  FloquetBaixo: Floquet Port Faces=Air_Domain.face(-z) NumModes=4 Modes{Mode1{CharImp=Zpi} Mode2{CharImp=Zpi} Mode3{CharImp=Zpi} Mode4{CharImp=Zpi}} PhaseDelay=UseScanAngle Phi=0deg Theta=theta_inc LatticeAVector{(-0.16, -0.16, -1) -> (0.16, -0.16, -1)} LatticeBVector{(-0.16, -0.16, -1) -> (-0.16, 0.16, -1)} ModesCalculator{Frequency=1GHz PhiStart=0deg PhiStop=0deg PhiStep=0deg ThetaStart=0deg ThetaStop=0deg ThetaStep=0deg} ModesList{Mode{ModeNumber=1 IndexM=0 IndexN=0 KC2=0 PropagationState=Undefined Attenuation=0 PolarizationState=TE AffectsRefinement} Mode{ModeNumber=2 IndexM=0 IndexN=0 KC2=0 PropagationState=Undefined Attenuation=0 PolarizationState=TM AffectsRefinement} Mode{ModeNumber=3 IndexM=-1 IndexN=0 KC2=385531421917553 PropagationState=Undefined Attenuation=1.7054704e+08 PolarizationState=TE AffectsRefinement} Mode{ModeNumber=4 IndexM=0 IndexN=-1 KC2=385531421917553 PropagationState=Undefined Attenuation=1.7054704e+08 PolarizationState=TE AffectsRefinement}}
setups:
  Setup1: HfssDriven Frequency=666.2THz MaxDeltaS=0.01 MaximumPasses=15 MinimumPasses=1 MinimumConvergedPasses=1 PercentRefinement=30 BasisOrder=1 PortAccuracy=2 DrivenSolverType="Direct Solver"
    sweep Varredura: 187.4THz to 666.2THz, 401 points; Type=Interpolating InterpTolerance=0.5 InterpMaxSolns=250 PassivityErrorTolerance=0.0001
source amplitudes:
  FloquetCima:1: 1W 0deg
  FloquetCima:2, FloquetCima:3, FloquetCima:4, FloquetBaixo:1..FloquetBaixo:4: 0W 0deg

design G0100_disco (HFSS, HFSS Modal Network, model units um)
variables:
  theta_inc = 0deg
geometry:
  Au_disco [Au_JC] = cylinder(axis=Z, base_centre=(0um, 0um, 0um), radius=0.103um, height=0.03um)
  Air_Domain [vacuum] = box(corner=(-0.16um, -0.16um, -1um), size=(0.32um, 0.32um, 2.03um))
  Au_disco_1 = Au_disco.copy()
  Air_Domain.subtract(Au_disco_1)
boundaries and excitations:
  LatticePair_57WQOO: Lattice Pair Faces=Air_Domain.face(-x, +x) CoordSysVector{(-0.16, -0.16, -1) -> (-0.16, -0.16, 1.03)} PhaseDelay=UseScanAngle Phi=0deg Theta=theta_inc
  LatticePair_WFWVDR: Lattice Pair Faces=Air_Domain.face(-y, +y) CoordSysVector{(0.16, -0.16, -1) -> (0.16, -0.16, 1.03)} PhaseDelay=UseScanAngle Phi=0deg Theta=theta_inc
  FloquetCima: Floquet Port Faces=Air_Domain.face(+z) NumModes=4 Modes{Mode1{CharImp=Zpi} Mode2{CharImp=Zpi} Mode3{CharImp=Zpi} Mode4{CharImp=Zpi}} PhaseDelay=UseScanAngle Phi=0deg Theta=theta_inc LatticeAVector{(-0.16, -0.16, 1.03) -> (0.16, -0.16, 1.03)} LatticeBVector{(-0.16, -0.16, 1.03) -> (-0.16, 0.16, 1.03)} ModesCalculator{Frequency=1GHz PhiStart=0deg PhiStop=0deg PhiStep=0deg ThetaStart=0deg ThetaStop=0deg ThetaStep=0deg} ModesList{Mode{ModeNumber=1 IndexM=0 IndexN=0 KC2=0 PropagationState=Undefined Attenuation=0 PolarizationState=TE AffectsRefinement} Mode{ModeNumber=2 IndexM=0 IndexN=0 KC2=0 PropagationState=Undefined Attenuation=0 PolarizationState=TM AffectsRefinement} Mode{ModeNumber=3 IndexM=-1 IndexN=0 KC2=385531421917553 PropagationState=Undefined Attenuation=1.7054704e+08 PolarizationState=TE AffectsRefinement} Mode{ModeNumber=4 IndexM=0 IndexN=-1 KC2=385531421917553 PropagationState=Undefined Attenuation=1.7054704e+08 PolarizationState=TE AffectsRefinement}}
  FloquetBaixo: Floquet Port Faces=Air_Domain.face(-z) NumModes=4 Modes{Mode1{CharImp=Zpi} Mode2{CharImp=Zpi} Mode3{CharImp=Zpi} Mode4{CharImp=Zpi}} PhaseDelay=UseScanAngle Phi=0deg Theta=theta_inc LatticeAVector{(-0.16, -0.16, -1) -> (0.16, -0.16, -1)} LatticeBVector{(-0.16, -0.16, -1) -> (-0.16, 0.16, -1)} ModesCalculator{Frequency=1GHz PhiStart=0deg PhiStop=0deg PhiStep=0deg ThetaStart=0deg ThetaStop=0deg ThetaStep=0deg} ModesList{Mode{ModeNumber=1 IndexM=0 IndexN=0 KC2=0 PropagationState=Undefined Attenuation=0 PolarizationState=TE AffectsRefinement} Mode{ModeNumber=2 IndexM=0 IndexN=0 KC2=0 PropagationState=Undefined Attenuation=0 PolarizationState=TM AffectsRefinement} Mode{ModeNumber=3 IndexM=-1 IndexN=0 KC2=385531421917553 PropagationState=Undefined Attenuation=1.7054704e+08 PolarizationState=TE AffectsRefinement} Mode{ModeNumber=4 IndexM=0 IndexN=-1 KC2=385531421917553 PropagationState=Undefined Attenuation=1.7054704e+08 PolarizationState=TE AffectsRefinement}}
setups:
  Setup1: HfssDriven Frequency=666.2THz MaxDeltaS=0.01 MaximumPasses=15 MinimumPasses=1 MinimumConvergedPasses=1 PercentRefinement=30 BasisOrder=1 PortAccuracy=2 DrivenSolverType="Direct Solver"
    sweep Varredura: 187.4THz to 666.2THz, 401 points; Type=Interpolating InterpTolerance=0.5 InterpMaxSolns=250 PassivityErrorTolerance=0.0001
source amplitudes:
  FloquetCima:1: 1W 0deg
  FloquetCima:2, FloquetCima:3, FloquetCima:4, FloquetBaixo:1..FloquetBaixo:4: 0W 0deg

design G0029_disco (HFSS, HFSS Modal Network, model units um)
variables:
  theta_inc = 0deg
geometry:
  Au_disco [Au_JC] = cylinder(axis=Z, base_centre=(0um, 0um, 0um), radius=0.071um, height=0.03um)
  Air_Domain [vacuum] = box(corner=(-0.16um, -0.16um, -1um), size=(0.32um, 0.32um, 2.03um))
  Au_disco_1 = Au_disco.copy()
  Air_Domain.subtract(Au_disco_1)
boundaries and excitations:
  LatticePair_QQBN1E: Lattice Pair Faces=Air_Domain.face(-x, +x) CoordSysVector{(-0.16, -0.16, -1) -> (-0.16, -0.16, 1.03)} PhaseDelay=UseScanAngle Phi=0deg Theta=theta_inc
  LatticePair_Z3EFN3: Lattice Pair Faces=Air_Domain.face(-y, +y) CoordSysVector{(0.16, -0.16, -1) -> (0.16, -0.16, 1.03)} PhaseDelay=UseScanAngle Phi=0deg Theta=theta_inc
  FloquetCima: Floquet Port Faces=Air_Domain.face(+z) NumModes=4 Modes{Mode1{CharImp=Zpi} Mode2{CharImp=Zpi} Mode3{CharImp=Zpi} Mode4{CharImp=Zpi}} PhaseDelay=UseScanAngle Phi=0deg Theta=theta_inc LatticeAVector{(-0.16, -0.16, 1.03) -> (0.16, -0.16, 1.03)} LatticeBVector{(-0.16, -0.16, 1.03) -> (-0.16, 0.16, 1.03)} ModesCalculator{Frequency=1GHz PhiStart=0deg PhiStop=0deg PhiStep=0deg ThetaStart=0deg ThetaStop=0deg ThetaStep=0deg} ModesList{Mode{ModeNumber=1 IndexM=0 IndexN=0 KC2=0 PropagationState=Undefined Attenuation=0 PolarizationState=TE AffectsRefinement} Mode{ModeNumber=2 IndexM=0 IndexN=0 KC2=0 PropagationState=Undefined Attenuation=0 PolarizationState=TM AffectsRefinement} Mode{ModeNumber=3 IndexM=-1 IndexN=0 KC2=385531421917553 PropagationState=Undefined Attenuation=1.7054704e+08 PolarizationState=TE AffectsRefinement} Mode{ModeNumber=4 IndexM=0 IndexN=-1 KC2=385531421917553 PropagationState=Undefined Attenuation=1.7054704e+08 PolarizationState=TE AffectsRefinement}}
  FloquetBaixo: Floquet Port Faces=Air_Domain.face(-z) NumModes=4 Modes{Mode1{CharImp=Zpi} Mode2{CharImp=Zpi} Mode3{CharImp=Zpi} Mode4{CharImp=Zpi}} PhaseDelay=UseScanAngle Phi=0deg Theta=theta_inc LatticeAVector{(-0.16, -0.16, -1) -> (0.16, -0.16, -1)} LatticeBVector{(-0.16, -0.16, -1) -> (-0.16, 0.16, -1)} ModesCalculator{Frequency=1GHz PhiStart=0deg PhiStop=0deg PhiStep=0deg ThetaStart=0deg ThetaStop=0deg ThetaStep=0deg} ModesList{Mode{ModeNumber=1 IndexM=0 IndexN=0 KC2=0 PropagationState=Undefined Attenuation=0 PolarizationState=TE AffectsRefinement} Mode{ModeNumber=2 IndexM=0 IndexN=0 KC2=0 PropagationState=Undefined Attenuation=0 PolarizationState=TM AffectsRefinement} Mode{ModeNumber=3 IndexM=-1 IndexN=0 KC2=385531421917553 PropagationState=Undefined Attenuation=1.7054704e+08 PolarizationState=TE AffectsRefinement} Mode{ModeNumber=4 IndexM=0 IndexN=-1 KC2=385531421917553 PropagationState=Undefined Attenuation=1.7054704e+08 PolarizationState=TE AffectsRefinement}}
setups:
  Setup1: HfssDriven Frequency=666.2THz MaxDeltaS=0.01 MaximumPasses=15 MinimumPasses=1 MinimumConvergedPasses=1 PercentRefinement=30 BasisOrder=1 PortAccuracy=2 DrivenSolverType="Direct Solver"
    sweep Varredura: 187.4THz to 666.2THz, 401 points; Type=Interpolating InterpTolerance=0.5 InterpMaxSolns=250 PassivityErrorTolerance=0.0001
source amplitudes:
  FloquetCima:1: 1W 0deg
  FloquetCima:2, FloquetCima:3, FloquetCima:4, FloquetBaixo:1..FloquetBaixo:4: 0W 0deg

design G0008_disco (HFSS, HFSS Modal Network, model units um)
variables:
  theta_inc = 0deg
geometry:
  Au_disco [Au_JC] = cylinder(axis=Z, base_centre=(0um, 0um, 0um), radius=0.075um, height=0.03um)
  Air_Domain [vacuum] = box(corner=(-0.16um, -0.16um, -1um), size=(0.32um, 0.32um, 2.03um))
  Au_disco_1 = Au_disco.copy()
  Air_Domain.subtract(Au_disco_1)
boundaries and excitations:
  LatticePair_YCNDDH: Lattice Pair Faces=Air_Domain.face(-x, +x) CoordSysVector{(-0.16, -0.16, -1) -> (-0.16, -0.16, 1.03)} PhaseDelay=UseScanAngle Phi=0deg Theta=theta_inc
  LatticePair_ZT6X8I: Lattice Pair Faces=Air_Domain.face(-y, +y) CoordSysVector{(0.16, -0.16, -1) -> (0.16, -0.16, 1.03)} PhaseDelay=UseScanAngle Phi=0deg Theta=theta_inc
  FloquetCima: Floquet Port Faces=Air_Domain.face(+z) NumModes=4 Modes{Mode1{CharImp=Zpi} Mode2{CharImp=Zpi} Mode3{CharImp=Zpi} Mode4{CharImp=Zpi}} PhaseDelay=UseScanAngle Phi=0deg Theta=theta_inc LatticeAVector{(-0.16, -0.16, 1.03) -> (0.16, -0.16, 1.03)} LatticeBVector{(-0.16, -0.16, 1.03) -> (-0.16, 0.16, 1.03)} ModesCalculator{Frequency=1GHz PhiStart=0deg PhiStop=0deg PhiStep=0deg ThetaStart=0deg ThetaStop=0deg ThetaStep=0deg} ModesList{Mode{ModeNumber=1 IndexM=0 IndexN=0 KC2=0 PropagationState=Undefined Attenuation=0 PolarizationState=TE AffectsRefinement} Mode{ModeNumber=2 IndexM=0 IndexN=0 KC2=0 PropagationState=Undefined Attenuation=0 PolarizationState=TM AffectsRefinement} Mode{ModeNumber=3 IndexM=-1 IndexN=0 KC2=385531421917553 PropagationState=Undefined Attenuation=1.7054704e+08 PolarizationState=TE AffectsRefinement} Mode{ModeNumber=4 IndexM=0 IndexN=-1 KC2=385531421917553 PropagationState=Undefined Attenuation=1.7054704e+08 PolarizationState=TE AffectsRefinement}}
  FloquetBaixo: Floquet Port Faces=Air_Domain.face(-z) NumModes=4 Modes{Mode1{CharImp=Zpi} Mode2{CharImp=Zpi} Mode3{CharImp=Zpi} Mode4{CharImp=Zpi}} PhaseDelay=UseScanAngle Phi=0deg Theta=theta_inc LatticeAVector{(-0.16, -0.16, -1) -> (0.16, -0.16, -1)} LatticeBVector{(-0.16, -0.16, -1) -> (-0.16, 0.16, -1)} ModesCalculator{Frequency=1GHz PhiStart=0deg PhiStop=0deg PhiStep=0deg ThetaStart=0deg ThetaStop=0deg ThetaStep=0deg} ModesList{Mode{ModeNumber=1 IndexM=0 IndexN=0 KC2=0 PropagationState=Undefined Attenuation=0 PolarizationState=TE AffectsRefinement} Mode{ModeNumber=2 IndexM=0 IndexN=0 KC2=0 PropagationState=Undefined Attenuation=0 PolarizationState=TM AffectsRefinement} Mode{ModeNumber=3 IndexM=-1 IndexN=0 KC2=385531421917553 PropagationState=Undefined Attenuation=1.7054704e+08 PolarizationState=TE AffectsRefinement} Mode{ModeNumber=4 IndexM=0 IndexN=-1 KC2=385531421917553 PropagationState=Undefined Attenuation=1.7054704e+08 PolarizationState=TE AffectsRefinement}}
setups:
  Setup1: HfssDriven Frequency=666.2THz MaxDeltaS=0.01 MaximumPasses=15 MinimumPasses=1 MinimumConvergedPasses=1 PercentRefinement=30 BasisOrder=1 PortAccuracy=2 DrivenSolverType="Direct Solver"
    sweep Varredura: 187.4THz to 666.2THz, 401 points; Type=Interpolating InterpTolerance=0.5 InterpMaxSolns=250 PassivityErrorTolerance=0.0001
source amplitudes:
  FloquetCima:1: 1W 0deg
  FloquetCima:2, FloquetCima:3, FloquetCima:4, FloquetBaixo:1..FloquetBaixo:4: 0W 0deg

design G0050_disco (HFSS, HFSS Modal Network, model units um)
variables:
  theta_inc = 0deg
geometry:
  Au_disco [Au_JC] = cylinder(axis=Z, base_centre=(0um, 0um, 0um), radius=0.103um, height=0.03um)
  Air_Domain [vacuum] = box(corner=(-0.16um, -0.16um, -1um), size=(0.32um, 0.32um, 2.03um))
  Au_disco_1 = Au_disco.copy()
  Air_Domain.subtract(Au_disco_1)
boundaries and excitations:
  LatticePair_FRYJOM: Lattice Pair Faces=Air_Domain.face(-x, +x) CoordSysVector{(-0.16, -0.16, -1) -> (-0.16, -0.16, 1.03)} PhaseDelay=UseScanAngle Phi=0deg Theta=theta_inc
  LatticePair_YNO6RC: Lattice Pair Faces=Air_Domain.face(-y, +y) CoordSysVector{(0.16, -0.16, -1) -> (0.16, -0.16, 1.03)} PhaseDelay=UseScanAngle Phi=0deg Theta=theta_inc
  FloquetCima: Floquet Port Faces=Air_Domain.face(+z) NumModes=4 Modes{Mode1{CharImp=Zpi} Mode2{CharImp=Zpi} Mode3{CharImp=Zpi} Mode4{CharImp=Zpi}} PhaseDelay=UseScanAngle Phi=0deg Theta=theta_inc LatticeAVector{(-0.16, -0.16, 1.03) -> (0.16, -0.16, 1.03)} LatticeBVector{(-0.16, -0.16, 1.03) -> (-0.16, 0.16, 1.03)} ModesCalculator{Frequency=1GHz PhiStart=0deg PhiStop=0deg PhiStep=0deg ThetaStart=0deg ThetaStop=0deg ThetaStep=0deg} ModesList{Mode{ModeNumber=1 IndexM=0 IndexN=0 KC2=0 PropagationState=Undefined Attenuation=0 PolarizationState=TE AffectsRefinement} Mode{ModeNumber=2 IndexM=0 IndexN=0 KC2=0 PropagationState=Undefined Attenuation=0 PolarizationState=TM AffectsRefinement} Mode{ModeNumber=3 IndexM=-1 IndexN=0 KC2=385531421917553 PropagationState=Undefined Attenuation=1.7054704e+08 PolarizationState=TE AffectsRefinement} Mode{ModeNumber=4 IndexM=0 IndexN=-1 KC2=385531421917553 PropagationState=Undefined Attenuation=1.7054704e+08 PolarizationState=TE AffectsRefinement}}
  FloquetBaixo: Floquet Port Faces=Air_Domain.face(-z) NumModes=4 Modes{Mode1{CharImp=Zpi} Mode2{CharImp=Zpi} Mode3{CharImp=Zpi} Mode4{CharImp=Zpi}} PhaseDelay=UseScanAngle Phi=0deg Theta=theta_inc LatticeAVector{(-0.16, -0.16, -1) -> (0.16, -0.16, -1)} LatticeBVector{(-0.16, -0.16, -1) -> (-0.16, 0.16, -1)} ModesCalculator{Frequency=1GHz PhiStart=0deg PhiStop=0deg PhiStep=0deg ThetaStart=0deg ThetaStop=0deg ThetaStep=0deg} ModesList{Mode{ModeNumber=1 IndexM=0 IndexN=0 KC2=0 PropagationState=Undefined Attenuation=0 PolarizationState=TE AffectsRefinement} Mode{ModeNumber=2 IndexM=0 IndexN=0 KC2=0 PropagationState=Undefined Attenuation=0 PolarizationState=TM AffectsRefinement} Mode{ModeNumber=3 IndexM=-1 IndexN=0 KC2=385531421917553 PropagationState=Undefined Attenuation=1.7054704e+08 PolarizationState=TE AffectsRefinement} Mode{ModeNumber=4 IndexM=0 IndexN=-1 KC2=385531421917553 PropagationState=Undefined Attenuation=1.7054704e+08 PolarizationState=TE AffectsRefinement}}
setups:
  Setup1: HfssDriven Frequency=666.2THz MaxDeltaS=0.01 MaximumPasses=15 MinimumPasses=1 MinimumConvergedPasses=1 PercentRefinement=30 BasisOrder=1 PortAccuracy=2 DrivenSolverType="Direct Solver"
    sweep Varredura: 187.4THz to 666.2THz, 401 points; Type=Interpolating InterpTolerance=0.5 InterpMaxSolns=250 PassivityErrorTolerance=0.0001
source amplitudes:
  FloquetCima:1: 1W 0deg
  FloquetCima:2, FloquetCima:3, FloquetCima:4, FloquetBaixo:1..FloquetBaixo:4: 0W 0deg

design G0139_quadrado (HFSS, HFSS Modal Network, model units um)
variables:
  theta_inc = 0deg
geometry:
  Au_quadrado [Au_JC] = box(corner=(-0.1065um, -0.1065um, 0um), size=(0.213um, 0.213um, 0.03um))
  Air_Domain [vacuum] = box(corner=(-0.16um, -0.16um, -1um), size=(0.32um, 0.32um, 2.03um))
  Au_quadrado_1 = Au_quadrado.copy()
  Air_Domain.subtract(Au_quadrado_1)
boundaries and excitations:
  LatticePair_61KP8E: Lattice Pair Faces=Air_Domain.face(-x, +x) CoordSysVector{(-0.16, -0.16, -1) -> (-0.16, -0.16, 1.03)} PhaseDelay=UseScanAngle Phi=0deg Theta=theta_inc
  LatticePair_ND1WN8: Lattice Pair Faces=Air_Domain.face(-y, +y) CoordSysVector{(0.16, -0.16, -1) -> (0.16, -0.16, 1.03)} PhaseDelay=UseScanAngle Phi=0deg Theta=theta_inc
  FloquetCima: Floquet Port Faces=Air_Domain.face(+z) NumModes=4 Modes{Mode1{CharImp=Zpi} Mode2{CharImp=Zpi} Mode3{CharImp=Zpi} Mode4{CharImp=Zpi}} PhaseDelay=UseScanAngle Phi=0deg Theta=theta_inc LatticeAVector{(-0.16, -0.16, 1.03) -> (0.16, -0.16, 1.03)} LatticeBVector{(-0.16, -0.16, 1.03) -> (-0.16, 0.16, 1.03)} ModesCalculator{Frequency=1GHz PhiStart=0deg PhiStop=0deg PhiStep=0deg ThetaStart=0deg ThetaStop=0deg ThetaStep=0deg} ModesList{Mode{ModeNumber=1 IndexM=0 IndexN=0 KC2=0 PropagationState=Undefined Attenuation=0 PolarizationState=TE AffectsRefinement} Mode{ModeNumber=2 IndexM=0 IndexN=0 KC2=0 PropagationState=Undefined Attenuation=0 PolarizationState=TM AffectsRefinement} Mode{ModeNumber=3 IndexM=-1 IndexN=0 KC2=385531421917553 PropagationState=Undefined Attenuation=1.7054704e+08 PolarizationState=TE AffectsRefinement} Mode{ModeNumber=4 IndexM=0 IndexN=-1 KC2=385531421917553 PropagationState=Undefined Attenuation=1.7054704e+08 PolarizationState=TE AffectsRefinement}}
  FloquetBaixo: Floquet Port Faces=Air_Domain.face(-z) NumModes=4 Modes{Mode1{CharImp=Zpi} Mode2{CharImp=Zpi} Mode3{CharImp=Zpi} Mode4{CharImp=Zpi}} PhaseDelay=UseScanAngle Phi=0deg Theta=theta_inc LatticeAVector{(-0.16, -0.16, -1) -> (0.16, -0.16, -1)} LatticeBVector{(-0.16, -0.16, -1) -> (-0.16, 0.16, -1)} ModesCalculator{Frequency=1GHz PhiStart=0deg PhiStop=0deg PhiStep=0deg ThetaStart=0deg ThetaStop=0deg ThetaStep=0deg} ModesList{Mode{ModeNumber=1 IndexM=0 IndexN=0 KC2=0 PropagationState=Undefined Attenuation=0 PolarizationState=TE AffectsRefinement} Mode{ModeNumber=2 IndexM=0 IndexN=0 KC2=0 PropagationState=Undefined Attenuation=0 PolarizationState=TM AffectsRefinement} Mode{ModeNumber=3 IndexM=-1 IndexN=0 KC2=385531421917553 PropagationState=Undefined Attenuation=1.7054704e+08 PolarizationState=TE AffectsRefinement} Mode{ModeNumber=4 IndexM=0 IndexN=-1 KC2=385531421917553 PropagationState=Undefined Attenuation=1.7054704e+08 PolarizationState=TE AffectsRefinement}}
setups:
  Setup1: HfssDriven Frequency=666.2THz MaxDeltaS=0.01 MaximumPasses=15 MinimumPasses=1 MinimumConvergedPasses=1 PercentRefinement=30 BasisOrder=1 PortAccuracy=2 DrivenSolverType="Direct Solver"
    sweep Varredura: 187.4THz to 666.2THz, 401 points; Type=Interpolating InterpTolerance=0.5 InterpMaxSolns=250 PassivityErrorTolerance=0.0001
source amplitudes:
  FloquetCima:1: 1W 0deg
  FloquetCima:2, FloquetCima:3, FloquetCima:4, FloquetBaixo:1..FloquetBaixo:4: 0W 0deg

design G0180_quadrado (HFSS, HFSS Modal Network, model units um)
variables:
  theta_inc = 0deg
geometry:
  Au_quadrado [Au_JC] = box(corner=(-0.097um, -0.097um, 0um), size=(0.194um, 0.194um, 0.03um))
  Air_Domain [vacuum] = box(corner=(-0.16um, -0.16um, -1um), size=(0.32um, 0.32um, 2.03um))
  Au_quadrado_1 = Au_quadrado.copy()
  Air_Domain.subtract(Au_quadrado_1)
boundaries and excitations:
  LatticePair_TB6V1E: Lattice Pair Faces=Air_Domain.face(-x, +x) CoordSysVector{(-0.16, -0.16, -1) -> (-0.16, -0.16, 1.03)} PhaseDelay=UseScanAngle Phi=0deg Theta=theta_inc
  LatticePair_I0TLEY: Lattice Pair Faces=Air_Domain.face(-y, +y) CoordSysVector{(0.16, -0.16, -1) -> (0.16, -0.16, 1.03)} PhaseDelay=UseScanAngle Phi=0deg Theta=theta_inc
  FloquetCima: Floquet Port Faces=Air_Domain.face(+z) NumModes=4 Modes{Mode1{CharImp=Zpi} Mode2{CharImp=Zpi} Mode3{CharImp=Zpi} Mode4{CharImp=Zpi}} PhaseDelay=UseScanAngle Phi=0deg Theta=theta_inc LatticeAVector{(-0.16, -0.16, 1.03) -> (0.16, -0.16, 1.03)} LatticeBVector{(-0.16, -0.16, 1.03) -> (-0.16, 0.16, 1.03)} ModesCalculator{Frequency=1GHz PhiStart=0deg PhiStop=0deg PhiStep=0deg ThetaStart=0deg ThetaStop=0deg ThetaStep=0deg} ModesList{Mode{ModeNumber=1 IndexM=0 IndexN=0 KC2=0 PropagationState=Undefined Attenuation=0 PolarizationState=TE AffectsRefinement} Mode{ModeNumber=2 IndexM=0 IndexN=0 KC2=0 PropagationState=Undefined Attenuation=0 PolarizationState=TM AffectsRefinement} Mode{ModeNumber=3 IndexM=-1 IndexN=0 KC2=385531421917553 PropagationState=Undefined Attenuation=1.7054704e+08 PolarizationState=TE AffectsRefinement} Mode{ModeNumber=4 IndexM=0 IndexN=-1 KC2=385531421917553 PropagationState=Undefined Attenuation=1.7054704e+08 PolarizationState=TE AffectsRefinement}}
  FloquetBaixo: Floquet Port Faces=Air_Domain.face(-z) NumModes=4 Modes{Mode1{CharImp=Zpi} Mode2{CharImp=Zpi} Mode3{CharImp=Zpi} Mode4{CharImp=Zpi}} PhaseDelay=UseScanAngle Phi=0deg Theta=theta_inc LatticeAVector{(-0.16, -0.16, -1) -> (0.16, -0.16, -1)} LatticeBVector{(-0.16, -0.16, -1) -> (-0.16, 0.16, -1)} ModesCalculator{Frequency=1GHz PhiStart=0deg PhiStop=0deg PhiStep=0deg ThetaStart=0deg ThetaStop=0deg ThetaStep=0deg} ModesList{Mode{ModeNumber=1 IndexM=0 IndexN=0 KC2=0 PropagationState=Undefined Attenuation=0 PolarizationState=TE AffectsRefinement} Mode{ModeNumber=2 IndexM=0 IndexN=0 KC2=0 PropagationState=Undefined Attenuation=0 PolarizationState=TM AffectsRefinement} Mode{ModeNumber=3 IndexM=-1 IndexN=0 KC2=385531421917553 PropagationState=Undefined Attenuation=1.7054704e+08 PolarizationState=TE AffectsRefinement} Mode{ModeNumber=4 IndexM=0 IndexN=-1 KC2=385531421917553 PropagationState=Undefined Attenuation=1.7054704e+08 PolarizationState=TE AffectsRefinement}}
setups:
  Setup1: HfssDriven Frequency=666.2THz MaxDeltaS=0.01 MaximumPasses=15 MinimumPasses=1 MinimumConvergedPasses=1 PercentRefinement=30 BasisOrder=1 PortAccuracy=2 DrivenSolverType="Direct Solver"
    sweep Varredura: 187.4THz to 666.2THz, 401 points; Type=Interpolating InterpTolerance=0.5 InterpMaxSolns=250 PassivityErrorTolerance=0.0001
source amplitudes:
  FloquetCima:1: 1W 0deg
  FloquetCima:2, FloquetCima:3, FloquetCima:4, FloquetBaixo:1..FloquetBaixo:4: 0W 0deg

design G0188_quadrado (HFSS, HFSS Modal Network, model units um)
variables:
  theta_inc = 0deg
geometry:
  Au_quadrado [Au_JC] = box(corner=(-0.093um, -0.093um, 0um), size=(0.186um, 0.186um, 0.03um))
  Air_Domain [vacuum] = box(corner=(-0.16um, -0.16um, -1um), size=(0.32um, 0.32um, 2.03um))
  Au_quadrado_1 = Au_quadrado.copy()
  Air_Domain.subtract(Au_quadrado_1)
boundaries and excitations:
  LatticePair_VQ1PZ7: Lattice Pair Faces=Air_Domain.face(-x, +x) CoordSysVector{(-0.16, -0.16, -1) -> (-0.16, -0.16, 1.03)} PhaseDelay=UseScanAngle Phi=0deg Theta=theta_inc
  LatticePair_EOA9RF: Lattice Pair Faces=Air_Domain.face(-y, +y) CoordSysVector{(0.16, -0.16, -1) -> (0.16, -0.16, 1.03)} PhaseDelay=UseScanAngle Phi=0deg Theta=theta_inc
  FloquetCima: Floquet Port Faces=Air_Domain.face(+z) NumModes=4 Modes{Mode1{CharImp=Zpi} Mode2{CharImp=Zpi} Mode3{CharImp=Zpi} Mode4{CharImp=Zpi}} PhaseDelay=UseScanAngle Phi=0deg Theta=theta_inc LatticeAVector{(-0.16, -0.16, 1.03) -> (0.16, -0.16, 1.03)} LatticeBVector{(-0.16, -0.16, 1.03) -> (-0.16, 0.16, 1.03)} ModesCalculator{Frequency=1GHz PhiStart=0deg PhiStop=0deg PhiStep=0deg ThetaStart=0deg ThetaStop=0deg ThetaStep=0deg} ModesList{Mode{ModeNumber=1 IndexM=0 IndexN=0 KC2=0 PropagationState=Undefined Attenuation=0 PolarizationState=TE AffectsRefinement} Mode{ModeNumber=2 IndexM=0 IndexN=0 KC2=0 PropagationState=Undefined Attenuation=0 PolarizationState=TM AffectsRefinement} Mode{ModeNumber=3 IndexM=-1 IndexN=0 KC2=385531421917553 PropagationState=Undefined Attenuation=1.7054704e+08 PolarizationState=TE AffectsRefinement} Mode{ModeNumber=4 IndexM=0 IndexN=-1 KC2=385531421917553 PropagationState=Undefined Attenuation=1.7054704e+08 PolarizationState=TE AffectsRefinement}}
  FloquetBaixo: Floquet Port Faces=Air_Domain.face(-z) NumModes=4 Modes{Mode1{CharImp=Zpi} Mode2{CharImp=Zpi} Mode3{CharImp=Zpi} Mode4{CharImp=Zpi}} PhaseDelay=UseScanAngle Phi=0deg Theta=theta_inc LatticeAVector{(-0.16, -0.16, -1) -> (0.16, -0.16, -1)} LatticeBVector{(-0.16, -0.16, -1) -> (-0.16, 0.16, -1)} ModesCalculator{Frequency=1GHz PhiStart=0deg PhiStop=0deg PhiStep=0deg ThetaStart=0deg ThetaStop=0deg ThetaStep=0deg} ModesList{Mode{ModeNumber=1 IndexM=0 IndexN=0 KC2=0 PropagationState=Undefined Attenuation=0 PolarizationState=TE AffectsRefinement} Mode{ModeNumber=2 IndexM=0 IndexN=0 KC2=0 PropagationState=Undefined Attenuation=0 PolarizationState=TM AffectsRefinement} Mode{ModeNumber=3 IndexM=-1 IndexN=0 KC2=385531421917553 PropagationState=Undefined Attenuation=1.7054704e+08 PolarizationState=TE AffectsRefinement} Mode{ModeNumber=4 IndexM=0 IndexN=-1 KC2=385531421917553 PropagationState=Undefined Attenuation=1.7054704e+08 PolarizationState=TE AffectsRefinement}}
setups:
  Setup1: HfssDriven Frequency=666.2THz MaxDeltaS=0.01 MaximumPasses=15 MinimumPasses=1 MinimumConvergedPasses=1 PercentRefinement=30 BasisOrder=1 PortAccuracy=2 DrivenSolverType="Direct Solver"
    sweep Varredura: 187.4THz to 666.2THz, 401 points; Type=Interpolating InterpTolerance=0.5 InterpMaxSolns=250 PassivityErrorTolerance=0.0001
source amplitudes:
  FloquetCima:1: 1W 0deg
  FloquetCima:2, FloquetCima:3, FloquetCima:4, FloquetBaixo:1..FloquetBaixo:4: 0W 0deg

design G0196_quadrado (HFSS, HFSS Modal Network, model units um)
variables:
  theta_inc = 0deg
geometry:
  Au_quadrado [Au_JC] = box(corner=(-0.0365um, -0.0365um, 0um), size=(0.073um, 0.073um, 0.03um))
  Air_Domain [vacuum] = box(corner=(-0.16um, -0.16um, -1um), size=(0.32um, 0.32um, 2.03um))
  Au_quadrado_1 = Au_quadrado.copy()
  Air_Domain.subtract(Au_quadrado_1)
boundaries and excitations:
  LatticePair_X8SB4B: Lattice Pair Faces=Air_Domain.face(-x, +x) CoordSysVector{(-0.16, -0.16, -1) -> (-0.16, -0.16, 1.03)} PhaseDelay=UseScanAngle Phi=0deg Theta=theta_inc
  LatticePair_JYN0WG: Lattice Pair Faces=Air_Domain.face(-y, +y) CoordSysVector{(0.16, -0.16, -1) -> (0.16, -0.16, 1.03)} PhaseDelay=UseScanAngle Phi=0deg Theta=theta_inc
  FloquetCima: Floquet Port Faces=Air_Domain.face(+z) NumModes=4 Modes{Mode1{CharImp=Zpi} Mode2{CharImp=Zpi} Mode3{CharImp=Zpi} Mode4{CharImp=Zpi}} PhaseDelay=UseScanAngle Phi=0deg Theta=theta_inc LatticeAVector{(-0.16, -0.16, 1.03) -> (0.16, -0.16, 1.03)} LatticeBVector{(-0.16, -0.16, 1.03) -> (-0.16, 0.16, 1.03)} ModesCalculator{Frequency=1GHz PhiStart=0deg PhiStop=0deg PhiStep=0deg ThetaStart=0deg ThetaStop=0deg ThetaStep=0deg} ModesList{Mode{ModeNumber=1 IndexM=0 IndexN=0 KC2=0 PropagationState=Undefined Attenuation=0 PolarizationState=TE AffectsRefinement} Mode{ModeNumber=2 IndexM=0 IndexN=0 KC2=0 PropagationState=Undefined Attenuation=0 PolarizationState=TM AffectsRefinement} Mode{ModeNumber=3 IndexM=-1 IndexN=0 KC2=385531421917553 PropagationState=Undefined Attenuation=1.7054704e+08 PolarizationState=TE AffectsRefinement} Mode{ModeNumber=4 IndexM=0 IndexN=-1 KC2=385531421917553 PropagationState=Undefined Attenuation=1.7054704e+08 PolarizationState=TE AffectsRefinement}}
  FloquetBaixo: Floquet Port Faces=Air_Domain.face(-z) NumModes=4 Modes{Mode1{CharImp=Zpi} Mode2{CharImp=Zpi} Mode3{CharImp=Zpi} Mode4{CharImp=Zpi}} PhaseDelay=UseScanAngle Phi=0deg Theta=theta_inc LatticeAVector{(-0.16, -0.16, -1) -> (0.16, -0.16, -1)} LatticeBVector{(-0.16, -0.16, -1) -> (-0.16, 0.16, -1)} ModesCalculator{Frequency=1GHz PhiStart=0deg PhiStop=0deg PhiStep=0deg ThetaStart=0deg ThetaStop=0deg ThetaStep=0deg} ModesList{Mode{ModeNumber=1 IndexM=0 IndexN=0 KC2=0 PropagationState=Undefined Attenuation=0 PolarizationState=TE AffectsRefinement} Mode{ModeNumber=2 IndexM=0 IndexN=0 KC2=0 PropagationState=Undefined Attenuation=0 PolarizationState=TM AffectsRefinement} Mode{ModeNumber=3 IndexM=-1 IndexN=0 KC2=385531421917553 PropagationState=Undefined Attenuation=1.7054704e+08 PolarizationState=TE AffectsRefinement} Mode{ModeNumber=4 IndexM=0 IndexN=-1 KC2=385531421917553 PropagationState=Undefined Attenuation=1.7054704e+08 PolarizationState=TE AffectsRefinement}}
setups:
  Setup1: HfssDriven Frequency=666.2THz MaxDeltaS=0.01 MaximumPasses=15 MinimumPasses=1 MinimumConvergedPasses=1 PercentRefinement=30 BasisOrder=1 PortAccuracy=2 DrivenSolverType="Direct Solver"
    sweep Varredura: 187.4THz to 666.2THz, 401 points; Type=Interpolating InterpTolerance=0.5 InterpMaxSolns=250 PassivityErrorTolerance=0.0001
source amplitudes:
  FloquetCima:1: 1W 0deg
  FloquetCima:2, FloquetCima:3, FloquetCima:4, FloquetBaixo:1..FloquetBaixo:4: 0W 0deg

design G0152_quadrado (HFSS, HFSS Modal Network, model units um)
variables:
  theta_inc = 0deg
geometry:
  Au_quadrado [Au_JC] = box(corner=(-0.031um, -0.031um, 0um), size=(0.062um, 0.062um, 0.03um))
  Air_Domain [vacuum] = box(corner=(-0.16um, -0.16um, -1um), size=(0.32um, 0.32um, 2.03um))
  Au_quadrado_1 = Au_quadrado.copy()
  Air_Domain.subtract(Au_quadrado_1)
boundaries and excitations:
  LatticePair_MJEEMM: Lattice Pair Faces=Air_Domain.face(-x, +x) CoordSysVector{(-0.16, -0.16, -1) -> (-0.16, -0.16, 1.03)} PhaseDelay=UseScanAngle Phi=0deg Theta=theta_inc
  LatticePair_QIDRL6: Lattice Pair Faces=Air_Domain.face(-y, +y) CoordSysVector{(0.16, -0.16, -1) -> (0.16, -0.16, 1.03)} PhaseDelay=UseScanAngle Phi=0deg Theta=theta_inc
  FloquetCima: Floquet Port Faces=Air_Domain.face(+z) NumModes=4 Modes{Mode1{CharImp=Zpi} Mode2{CharImp=Zpi} Mode3{CharImp=Zpi} Mode4{CharImp=Zpi}} PhaseDelay=UseScanAngle Phi=0deg Theta=theta_inc LatticeAVector{(-0.16, -0.16, 1.03) -> (0.16, -0.16, 1.03)} LatticeBVector{(-0.16, -0.16, 1.03) -> (-0.16, 0.16, 1.03)} ModesCalculator{Frequency=1GHz PhiStart=0deg PhiStop=0deg PhiStep=0deg ThetaStart=0deg ThetaStop=0deg ThetaStep=0deg} ModesList{Mode{ModeNumber=1 IndexM=0 IndexN=0 KC2=0 PropagationState=Undefined Attenuation=0 PolarizationState=TE AffectsRefinement} Mode{ModeNumber=2 IndexM=0 IndexN=0 KC2=0 PropagationState=Undefined Attenuation=0 PolarizationState=TM AffectsRefinement} Mode{ModeNumber=3 IndexM=-1 IndexN=0 KC2=385531421917553 PropagationState=Undefined Attenuation=1.7054704e+08 PolarizationState=TE AffectsRefinement} Mode{ModeNumber=4 IndexM=0 IndexN=-1 KC2=385531421917553 PropagationState=Undefined Attenuation=1.7054704e+08 PolarizationState=TE AffectsRefinement}}
  FloquetBaixo: Floquet Port Faces=Air_Domain.face(-z) NumModes=4 Modes{Mode1{CharImp=Zpi} Mode2{CharImp=Zpi} Mode3{CharImp=Zpi} Mode4{CharImp=Zpi}} PhaseDelay=UseScanAngle Phi=0deg Theta=theta_inc LatticeAVector{(-0.16, -0.16, -1) -> (0.16, -0.16, -1)} LatticeBVector{(-0.16, -0.16, -1) -> (-0.16, 0.16, -1)} ModesCalculator{Frequency=1GHz PhiStart=0deg PhiStop=0deg PhiStep=0deg ThetaStart=0deg ThetaStop=0deg ThetaStep=0deg} ModesList{Mode{ModeNumber=1 IndexM=0 IndexN=0 KC2=0 PropagationState=Undefined Attenuation=0 PolarizationState=TE AffectsRefinement} Mode{ModeNumber=2 IndexM=0 IndexN=0 KC2=0 PropagationState=Undefined Attenuation=0 PolarizationState=TM AffectsRefinement} Mode{ModeNumber=3 IndexM=-1 IndexN=0 KC2=385531421917553 PropagationState=Undefined Attenuation=1.7054704e+08 PolarizationState=TE AffectsRefinement} Mode{ModeNumber=4 IndexM=0 IndexN=-1 KC2=385531421917553 PropagationState=Undefined Attenuation=1.7054704e+08 PolarizationState=TE AffectsRefinement}}
setups:
  Setup1: HfssDriven Frequency=666.2THz MaxDeltaS=0.01 MaximumPasses=15 MinimumPasses=1 MinimumConvergedPasses=1 PercentRefinement=30 BasisOrder=1 PortAccuracy=2 DrivenSolverType="Direct Solver"
    sweep Varredura: 187.4THz to 666.2THz, 401 points; Type=Interpolating InterpTolerance=0.5 InterpMaxSolns=250 PassivityErrorTolerance=0.0001
source amplitudes:
  FloquetCima:1: 1W 0deg
  FloquetCima:2, FloquetCima:3, FloquetCima:4, FloquetBaixo:1..FloquetBaixo:4: 0W 0deg

design G0138_quadrado (HFSS, HFSS Modal Network, model units um)
variables:
  theta_inc = 0deg
geometry:
  Au_quadrado [Au_JC] = box(corner=(-0.077um, -0.077um, 0um), size=(0.154um, 0.154um, 0.03um))
  Air_Domain [vacuum] = box(corner=(-0.16um, -0.16um, -1um), size=(0.32um, 0.32um, 2.03um))
  Au_quadrado_1 = Au_quadrado.copy()
  Air_Domain.subtract(Au_quadrado_1)
boundaries and excitations:
  LatticePair_2I81YM: Lattice Pair Faces=Air_Domain.face(-x, +x) CoordSysVector{(-0.16, -0.16, -1) -> (-0.16, -0.16, 1.03)} PhaseDelay=UseScanAngle Phi=0deg Theta=theta_inc
  LatticePair_Y4SONK: Lattice Pair Faces=Air_Domain.face(-y, +y) CoordSysVector{(0.16, -0.16, -1) -> (0.16, -0.16, 1.03)} PhaseDelay=UseScanAngle Phi=0deg Theta=theta_inc
  FloquetCima: Floquet Port Faces=Air_Domain.face(+z) NumModes=4 Modes{Mode1{CharImp=Zpi} Mode2{CharImp=Zpi} Mode3{CharImp=Zpi} Mode4{CharImp=Zpi}} PhaseDelay=UseScanAngle Phi=0deg Theta=theta_inc LatticeAVector{(-0.16, -0.16, 1.03) -> (0.16, -0.16, 1.03)} LatticeBVector{(-0.16, -0.16, 1.03) -> (-0.16, 0.16, 1.03)} ModesCalculator{Frequency=1GHz PhiStart=0deg PhiStop=0deg PhiStep=0deg ThetaStart=0deg ThetaStop=0deg ThetaStep=0deg} ModesList{Mode{ModeNumber=1 IndexM=0 IndexN=0 KC2=0 PropagationState=Undefined Attenuation=0 PolarizationState=TE AffectsRefinement} Mode{ModeNumber=2 IndexM=0 IndexN=0 KC2=0 PropagationState=Undefined Attenuation=0 PolarizationState=TM AffectsRefinement} Mode{ModeNumber=3 IndexM=-1 IndexN=0 KC2=385531421917553 PropagationState=Undefined Attenuation=1.7054704e+08 PolarizationState=TE AffectsRefinement} Mode{ModeNumber=4 IndexM=0 IndexN=-1 KC2=385531421917553 PropagationState=Undefined Attenuation=1.7054704e+08 PolarizationState=TE AffectsRefinement}}
  FloquetBaixo: Floquet Port Faces=Air_Domain.face(-z) NumModes=4 Modes{Mode1{CharImp=Zpi} Mode2{CharImp=Zpi} Mode3{CharImp=Zpi} Mode4{CharImp=Zpi}} PhaseDelay=UseScanAngle Phi=0deg Theta=theta_inc LatticeAVector{(-0.16, -0.16, -1) -> (0.16, -0.16, -1)} LatticeBVector{(-0.16, -0.16, -1) -> (-0.16, 0.16, -1)} ModesCalculator{Frequency=1GHz PhiStart=0deg PhiStop=0deg PhiStep=0deg ThetaStart=0deg ThetaStop=0deg ThetaStep=0deg} ModesList{Mode{ModeNumber=1 IndexM=0 IndexN=0 KC2=0 PropagationState=Undefined Attenuation=0 PolarizationState=TE AffectsRefinement} Mode{ModeNumber=2 IndexM=0 IndexN=0 KC2=0 PropagationState=Undefined Attenuation=0 PolarizationState=TM AffectsRefinement} Mode{ModeNumber=3 IndexM=-1 IndexN=0 KC2=385531421917553 PropagationState=Undefined Attenuation=1.7054704e+08 PolarizationState=TE AffectsRefinement} Mode{ModeNumber=4 IndexM=0 IndexN=-1 KC2=385531421917553 PropagationState=Undefined Attenuation=1.7054704e+08 PolarizationState=TE AffectsRefinement}}
setups:
  Setup1: HfssDriven Frequency=666.2THz MaxDeltaS=0.01 MaximumPasses=15 MinimumPasses=1 MinimumConvergedPasses=1 PercentRefinement=30 BasisOrder=1 PortAccuracy=2 DrivenSolverType="Direct Solver"
    sweep Varredura: 187.4THz to 666.2THz, 401 points; Type=Interpolating InterpTolerance=0.5 InterpMaxSolns=250 PassivityErrorTolerance=0.0001
source amplitudes:
  FloquetCima:1: 1W 0deg
  FloquetCima:2, FloquetCima:3, FloquetCima:4, FloquetBaixo:1..FloquetBaixo:4: 0W 0deg

design G0137_quadrado (HFSS, HFSS Modal Network, model units um)
variables:
  theta_inc = 0deg
geometry:
  Au_quadrado [Au_JC] = box(corner=(-0.048um, -0.048um, 0um), size=(0.096um, 0.096um, 0.03um))
  Air_Domain [vacuum] = box(corner=(-0.16um, -0.16um, -1um), size=(0.32um, 0.32um, 2.03um))
  Au_quadrado_1 = Au_quadrado.copy()
  Air_Domain.subtract(Au_quadrado_1)
boundaries and excitations:
  LatticePair_DU5J3U: Lattice Pair Faces=Air_Domain.face(-x, +x) CoordSysVector{(-0.16, -0.16, -1) -> (-0.16, -0.16, 1.03)} PhaseDelay=UseScanAngle Phi=0deg Theta=theta_inc
  LatticePair_S3ZS7U: Lattice Pair Faces=Air_Domain.face(-y, +y) CoordSysVector{(0.16, -0.16, -1) -> (0.16, -0.16, 1.03)} PhaseDelay=UseScanAngle Phi=0deg Theta=theta_inc
  FloquetCima: Floquet Port Faces=Air_Domain.face(+z) NumModes=4 Modes{Mode1{CharImp=Zpi} Mode2{CharImp=Zpi} Mode3{CharImp=Zpi} Mode4{CharImp=Zpi}} PhaseDelay=UseScanAngle Phi=0deg Theta=theta_inc LatticeAVector{(-0.16, -0.16, 1.03) -> (0.16, -0.16, 1.03)} LatticeBVector{(-0.16, -0.16, 1.03) -> (-0.16, 0.16, 1.03)} ModesCalculator{Frequency=1GHz PhiStart=0deg PhiStop=0deg PhiStep=0deg ThetaStart=0deg ThetaStop=0deg ThetaStep=0deg} ModesList{Mode{ModeNumber=1 IndexM=0 IndexN=0 KC2=0 PropagationState=Undefined Attenuation=0 PolarizationState=TE AffectsRefinement} Mode{ModeNumber=2 IndexM=0 IndexN=0 KC2=0 PropagationState=Undefined Attenuation=0 PolarizationState=TM AffectsRefinement} Mode{ModeNumber=3 IndexM=-1 IndexN=0 KC2=385531421917553 PropagationState=Undefined Attenuation=1.7054704e+08 PolarizationState=TE AffectsRefinement} Mode{ModeNumber=4 IndexM=0 IndexN=-1 KC2=385531421917553 PropagationState=Undefined Attenuation=1.7054704e+08 PolarizationState=TE AffectsRefinement}}
  FloquetBaixo: Floquet Port Faces=Air_Domain.face(-z) NumModes=4 Modes{Mode1{CharImp=Zpi} Mode2{CharImp=Zpi} Mode3{CharImp=Zpi} Mode4{CharImp=Zpi}} PhaseDelay=UseScanAngle Phi=0deg Theta=theta_inc LatticeAVector{(-0.16, -0.16, -1) -> (0.16, -0.16, -1)} LatticeBVector{(-0.16, -0.16, -1) -> (-0.16, 0.16, -1)} ModesCalculator{Frequency=1GHz PhiStart=0deg PhiStop=0deg PhiStep=0deg ThetaStart=0deg ThetaStop=0deg ThetaStep=0deg} ModesList{Mode{ModeNumber=1 IndexM=0 IndexN=0 KC2=0 PropagationState=Undefined Attenuation=0 PolarizationState=TE AffectsRefinement} Mode{ModeNumber=2 IndexM=0 IndexN=0 KC2=0 PropagationState=Undefined Attenuation=0 PolarizationState=TM AffectsRefinement} Mode{ModeNumber=3 IndexM=-1 IndexN=0 KC2=385531421917553 PropagationState=Undefined Attenuation=1.7054704e+08 PolarizationState=TE AffectsRefinement} Mode{ModeNumber=4 IndexM=0 IndexN=-1 KC2=385531421917553 PropagationState=Undefined Attenuation=1.7054704e+08 PolarizationState=TE AffectsRefinement}}
setups:
  Setup1: HfssDriven Frequency=666.2THz MaxDeltaS=0.01 MaximumPasses=15 MinimumPasses=1 MinimumConvergedPasses=1 PercentRefinement=30 BasisOrder=1 PortAccuracy=2 DrivenSolverType="Direct Solver"
    sweep Varredura: 187.4THz to 666.2THz, 401 points; Type=Interpolating InterpTolerance=0.5 InterpMaxSolns=250 PassivityErrorTolerance=0.0001
source amplitudes:
  FloquetCima:1: 1W 0deg
  FloquetCima:2, FloquetCima:3, FloquetCima:4, FloquetBaixo:1..FloquetBaixo:4: 0W 0deg

design G0147_quadrado (HFSS, HFSS Modal Network, model units um)
variables:
  theta_inc = 0deg
geometry:
  Au_quadrado [Au_JC] = box(corner=(-0.0545um, -0.0545um, 0um), size=(0.109um, 0.109um, 0.03um))
  Air_Domain [vacuum] = box(corner=(-0.16um, -0.16um, -1um), size=(0.32um, 0.32um, 2.03um))
  Au_quadrado_1 = Au_quadrado.copy()
  Air_Domain.subtract(Au_quadrado_1)
boundaries and excitations:
  LatticePair_6HNKUY: Lattice Pair Faces=Air_Domain.face(-x, +x) CoordSysVector{(-0.16, -0.16, -1) -> (-0.16, -0.16, 1.03)} PhaseDelay=UseScanAngle Phi=0deg Theta=theta_inc
  LatticePair_2YPWN0: Lattice Pair Faces=Air_Domain.face(-y, +y) CoordSysVector{(0.16, -0.16, -1) -> (0.16, -0.16, 1.03)} PhaseDelay=UseScanAngle Phi=0deg Theta=theta_inc
  FloquetCima: Floquet Port Faces=Air_Domain.face(+z) NumModes=4 Modes{Mode1{CharImp=Zpi} Mode2{CharImp=Zpi} Mode3{CharImp=Zpi} Mode4{CharImp=Zpi}} PhaseDelay=UseScanAngle Phi=0deg Theta=theta_inc LatticeAVector{(-0.16, -0.16, 1.03) -> (0.16, -0.16, 1.03)} LatticeBVector{(-0.16, -0.16, 1.03) -> (-0.16, 0.16, 1.03)} ModesCalculator{Frequency=1GHz PhiStart=0deg PhiStop=0deg PhiStep=0deg ThetaStart=0deg ThetaStop=0deg ThetaStep=0deg} ModesList{Mode{ModeNumber=1 IndexM=0 IndexN=0 KC2=0 PropagationState=Undefined Attenuation=0 PolarizationState=TE AffectsRefinement} Mode{ModeNumber=2 IndexM=0 IndexN=0 KC2=0 PropagationState=Undefined Attenuation=0 PolarizationState=TM AffectsRefinement} Mode{ModeNumber=3 IndexM=-1 IndexN=0 KC2=385531421917553 PropagationState=Undefined Attenuation=1.7054704e+08 PolarizationState=TE AffectsRefinement} Mode{ModeNumber=4 IndexM=0 IndexN=-1 KC2=385531421917553 PropagationState=Undefined Attenuation=1.7054704e+08 PolarizationState=TE AffectsRefinement}}
  FloquetBaixo: Floquet Port Faces=Air_Domain.face(-z) NumModes=4 Modes{Mode1{CharImp=Zpi} Mode2{CharImp=Zpi} Mode3{CharImp=Zpi} Mode4{CharImp=Zpi}} PhaseDelay=UseScanAngle Phi=0deg Theta=theta_inc LatticeAVector{(-0.16, -0.16, -1) -> (0.16, -0.16, -1)} LatticeBVector{(-0.16, -0.16, -1) -> (-0.16, 0.16, -1)} ModesCalculator{Frequency=1GHz PhiStart=0deg PhiStop=0deg PhiStep=0deg ThetaStart=0deg ThetaStop=0deg ThetaStep=0deg} ModesList{Mode{ModeNumber=1 IndexM=0 IndexN=0 KC2=0 PropagationState=Undefined Attenuation=0 PolarizationState=TE AffectsRefinement} Mode{ModeNumber=2 IndexM=0 IndexN=0 KC2=0 PropagationState=Undefined Attenuation=0 PolarizationState=TM AffectsRefinement} Mode{ModeNumber=3 IndexM=-1 IndexN=0 KC2=385531421917553 PropagationState=Undefined Attenuation=1.7054704e+08 PolarizationState=TE AffectsRefinement} Mode{ModeNumber=4 IndexM=0 IndexN=-1 KC2=385531421917553 PropagationState=Undefined Attenuation=1.7054704e+08 PolarizationState=TE AffectsRefinement}}
setups:
  Setup1: HfssDriven Frequency=666.2THz MaxDeltaS=0.01 MaximumPasses=15 MinimumPasses=1 MinimumConvergedPasses=1 PercentRefinement=30 BasisOrder=1 PortAccuracy=2 DrivenSolverType="Direct Solver"
    sweep Varredura: 187.4THz to 666.2THz, 401 points; Type=Interpolating InterpTolerance=0.5 InterpMaxSolns=250 PassivityErrorTolerance=0.0001
source amplitudes:
  FloquetCima:1: 1W 0deg
  FloquetCima:2, FloquetCima:3, FloquetCima:4, FloquetBaixo:1..FloquetBaixo:4: 0W 0deg

design G0103_quadrado (HFSS, HFSS Modal Network, model units um)
variables:
  theta_inc = 0deg
geometry:
  Au_quadrado [Au_JC] = box(corner=(-0.093um, -0.093um, 0um), size=(0.186um, 0.186um, 0.03um))
  Air_Domain [vacuum] = box(corner=(-0.16um, -0.16um, -1um), size=(0.32um, 0.32um, 2.03um))
  Au_quadrado_1 = Au_quadrado.copy()
  Air_Domain.subtract(Au_quadrado_1)
boundaries and excitations:
  LatticePair_0CFUMB: Lattice Pair Faces=Air_Domain.face(-x, +x) CoordSysVector{(-0.16, -0.16, -1) -> (-0.16, -0.16, 1.03)} PhaseDelay=UseScanAngle Phi=0deg Theta=theta_inc
  LatticePair_Y9ONXT: Lattice Pair Faces=Air_Domain.face(-y, +y) CoordSysVector{(0.16, -0.16, -1) -> (0.16, -0.16, 1.03)} PhaseDelay=UseScanAngle Phi=0deg Theta=theta_inc
  FloquetCima: Floquet Port Faces=Air_Domain.face(+z) NumModes=4 Modes{Mode1{CharImp=Zpi} Mode2{CharImp=Zpi} Mode3{CharImp=Zpi} Mode4{CharImp=Zpi}} PhaseDelay=UseScanAngle Phi=0deg Theta=theta_inc LatticeAVector{(-0.16, -0.16, 1.03) -> (0.16, -0.16, 1.03)} LatticeBVector{(-0.16, -0.16, 1.03) -> (-0.16, 0.16, 1.03)} ModesCalculator{Frequency=1GHz PhiStart=0deg PhiStop=0deg PhiStep=0deg ThetaStart=0deg ThetaStop=0deg ThetaStep=0deg} ModesList{Mode{ModeNumber=1 IndexM=0 IndexN=0 KC2=0 PropagationState=Undefined Attenuation=0 PolarizationState=TE AffectsRefinement} Mode{ModeNumber=2 IndexM=0 IndexN=0 KC2=0 PropagationState=Undefined Attenuation=0 PolarizationState=TM AffectsRefinement} Mode{ModeNumber=3 IndexM=-1 IndexN=0 KC2=385531421917553 PropagationState=Undefined Attenuation=1.7054704e+08 PolarizationState=TE AffectsRefinement} Mode{ModeNumber=4 IndexM=0 IndexN=-1 KC2=385531421917553 PropagationState=Undefined Attenuation=1.7054704e+08 PolarizationState=TE AffectsRefinement}}
  FloquetBaixo: Floquet Port Faces=Air_Domain.face(-z) NumModes=4 Modes{Mode1{CharImp=Zpi} Mode2{CharImp=Zpi} Mode3{CharImp=Zpi} Mode4{CharImp=Zpi}} PhaseDelay=UseScanAngle Phi=0deg Theta=theta_inc LatticeAVector{(-0.16, -0.16, -1) -> (0.16, -0.16, -1)} LatticeBVector{(-0.16, -0.16, -1) -> (-0.16, 0.16, -1)} ModesCalculator{Frequency=1GHz PhiStart=0deg PhiStop=0deg PhiStep=0deg ThetaStart=0deg ThetaStop=0deg ThetaStep=0deg} ModesList{Mode{ModeNumber=1 IndexM=0 IndexN=0 KC2=0 PropagationState=Undefined Attenuation=0 PolarizationState=TE AffectsRefinement} Mode{ModeNumber=2 IndexM=0 IndexN=0 KC2=0 PropagationState=Undefined Attenuation=0 PolarizationState=TM AffectsRefinement} Mode{ModeNumber=3 IndexM=-1 IndexN=0 KC2=385531421917553 PropagationState=Undefined Attenuation=1.7054704e+08 PolarizationState=TE AffectsRefinement} Mode{ModeNumber=4 IndexM=0 IndexN=-1 KC2=385531421917553 PropagationState=Undefined Attenuation=1.7054704e+08 PolarizationState=TE AffectsRefinement}}
setups:
  Setup1: HfssDriven Frequency=666.2THz MaxDeltaS=0.01 MaximumPasses=15 MinimumPasses=1 MinimumConvergedPasses=1 PercentRefinement=30 BasisOrder=1 PortAccuracy=2 DrivenSolverType="Direct Solver"
    sweep Varredura: 187.4THz to 666.2THz, 401 points; Type=Interpolating InterpTolerance=0.5 InterpMaxSolns=250 PassivityErrorTolerance=0.0001
source amplitudes:
  FloquetCima:1: 1W 0deg
  FloquetCima:2, FloquetCima:3, FloquetCima:4, FloquetBaixo:1..FloquetBaixo:4: 0W 0deg

design G0186_quadrado (HFSS, HFSS Modal Network, model units um)
variables:
  theta_inc = 0deg
geometry:
  Au_quadrado [Au_JC] = box(corner=(-0.0405um, -0.0405um, 0um), size=(0.081um, 0.081um, 0.03um))
  Air_Domain [vacuum] = box(corner=(-0.16um, -0.16um, -1um), size=(0.32um, 0.32um, 2.03um))
  Au_quadrado_1 = Au_quadrado.copy()
  Air_Domain.subtract(Au_quadrado_1)
boundaries and excitations:
  LatticePair_OOL8E3: Lattice Pair Faces=Air_Domain.face(-x, +x) CoordSysVector{(-0.16, -0.16, -1) -> (-0.16, -0.16, 1.03)} PhaseDelay=UseScanAngle Phi=0deg Theta=theta_inc
  LatticePair_THEQW8: Lattice Pair Faces=Air_Domain.face(-y, +y) CoordSysVector{(0.16, -0.16, -1) -> (0.16, -0.16, 1.03)} PhaseDelay=UseScanAngle Phi=0deg Theta=theta_inc
  FloquetCima: Floquet Port Faces=Air_Domain.face(+z) NumModes=4 Modes{Mode1{CharImp=Zpi} Mode2{CharImp=Zpi} Mode3{CharImp=Zpi} Mode4{CharImp=Zpi}} PhaseDelay=UseScanAngle Phi=0deg Theta=theta_inc LatticeAVector{(-0.16, -0.16, 1.03) -> (0.16, -0.16, 1.03)} LatticeBVector{(-0.16, -0.16, 1.03) -> (-0.16, 0.16, 1.03)} ModesCalculator{Frequency=1GHz PhiStart=0deg PhiStop=0deg PhiStep=0deg ThetaStart=0deg ThetaStop=0deg ThetaStep=0deg} ModesList{Mode{ModeNumber=1 IndexM=0 IndexN=0 KC2=0 PropagationState=Undefined Attenuation=0 PolarizationState=TE AffectsRefinement} Mode{ModeNumber=2 IndexM=0 IndexN=0 KC2=0 PropagationState=Undefined Attenuation=0 PolarizationState=TM AffectsRefinement} Mode{ModeNumber=3 IndexM=-1 IndexN=0 KC2=385531421917553 PropagationState=Undefined Attenuation=1.7054704e+08 PolarizationState=TE AffectsRefinement} Mode{ModeNumber=4 IndexM=0 IndexN=-1 KC2=385531421917553 PropagationState=Undefined Attenuation=1.7054704e+08 PolarizationState=TE AffectsRefinement}}
  FloquetBaixo: Floquet Port Faces=Air_Domain.face(-z) NumModes=4 Modes{Mode1{CharImp=Zpi} Mode2{CharImp=Zpi} Mode3{CharImp=Zpi} Mode4{CharImp=Zpi}} PhaseDelay=UseScanAngle Phi=0deg Theta=theta_inc LatticeAVector{(-0.16, -0.16, -1) -> (0.16, -0.16, -1)} LatticeBVector{(-0.16, -0.16, -1) -> (-0.16, 0.16, -1)} ModesCalculator{Frequency=1GHz PhiStart=0deg PhiStop=0deg PhiStep=0deg ThetaStart=0deg ThetaStop=0deg ThetaStep=0deg} ModesList{Mode{ModeNumber=1 IndexM=0 IndexN=0 KC2=0 PropagationState=Undefined Attenuation=0 PolarizationState=TE AffectsRefinement} Mode{ModeNumber=2 IndexM=0 IndexN=0 KC2=0 PropagationState=Undefined Attenuation=0 PolarizationState=TM AffectsRefinement} Mode{ModeNumber=3 IndexM=-1 IndexN=0 KC2=385531421917553 PropagationState=Undefined Attenuation=1.7054704e+08 PolarizationState=TE AffectsRefinement} Mode{ModeNumber=4 IndexM=0 IndexN=-1 KC2=385531421917553 PropagationState=Undefined Attenuation=1.7054704e+08 PolarizationState=TE AffectsRefinement}}
setups:
  Setup1: HfssDriven Frequency=666.2THz MaxDeltaS=0.01 MaximumPasses=15 MinimumPasses=1 MinimumConvergedPasses=1 PercentRefinement=30 BasisOrder=1 PortAccuracy=2 DrivenSolverType="Direct Solver"
    sweep Varredura: 187.4THz to 666.2THz, 401 points; Type=Interpolating InterpTolerance=0.5 InterpMaxSolns=250 PassivityErrorTolerance=0.0001
source amplitudes:
  FloquetCima:1: 1W 0deg
  FloquetCima:2, FloquetCima:3, FloquetCima:4, FloquetBaixo:1..FloquetBaixo:4: 0W 0deg

design G0298_anelC (HFSS, HFSS Modal Network, model units um)
variables:
  theta_inc = 0deg
geometry:
  Au_anelc [Au_JC] = cylinder(axis=Z, base_centre=(0um, 0um, 0um), radius=0.041um, height=0.03um)
  Au_anelc_furo = cylinder(axis=Z, base_centre=(0um, 0um, 0um), radius=0.019um, height=0.03um)
  Au_anelc.subtract(Au_anelc_furo)
  Air_Domain [vacuum] = box(corner=(-0.16um, -0.16um, -1um), size=(0.32um, 0.32um, 2.03um))
  Au_anelc_1 = Au_anelc.copy()
  Air_Domain.subtract(Au_anelc_1)
boundaries and excitations:
  LatticePair_2IAVFK: Lattice Pair Faces=Air_Domain.face(-x, +x) CoordSysVector{(-0.16, -0.16, -1) -> (-0.16, -0.16, 1.03)} PhaseDelay=UseScanAngle Phi=0deg Theta=theta_inc
  LatticePair_KQ2MLU: Lattice Pair Faces=Air_Domain.face(-y, +y) CoordSysVector{(0.16, -0.16, -1) -> (0.16, -0.16, 1.03)} PhaseDelay=UseScanAngle Phi=0deg Theta=theta_inc
  FloquetCima: Floquet Port Faces=Air_Domain.face(+z) NumModes=4 Modes{Mode1{CharImp=Zpi} Mode2{CharImp=Zpi} Mode3{CharImp=Zpi} Mode4{CharImp=Zpi}} PhaseDelay=UseScanAngle Phi=0deg Theta=theta_inc LatticeAVector{(-0.16, -0.16, 1.03) -> (0.16, -0.16, 1.03)} LatticeBVector{(-0.16, -0.16, 1.03) -> (-0.16, 0.16, 1.03)} ModesCalculator{Frequency=1GHz PhiStart=0deg PhiStop=0deg PhiStep=0deg ThetaStart=0deg ThetaStop=0deg ThetaStep=0deg} ModesList{Mode{ModeNumber=1 IndexM=0 IndexN=0 KC2=0 PropagationState=Undefined Attenuation=0 PolarizationState=TE AffectsRefinement} Mode{ModeNumber=2 IndexM=0 IndexN=0 KC2=0 PropagationState=Undefined Attenuation=0 PolarizationState=TM AffectsRefinement} Mode{ModeNumber=3 IndexM=-1 IndexN=0 KC2=385531421917553 PropagationState=Undefined Attenuation=1.7054704e+08 PolarizationState=TE AffectsRefinement} Mode{ModeNumber=4 IndexM=0 IndexN=-1 KC2=385531421917553 PropagationState=Undefined Attenuation=1.7054704e+08 PolarizationState=TE AffectsRefinement}}
  FloquetBaixo: Floquet Port Faces=Air_Domain.face(-z) NumModes=4 Modes{Mode1{CharImp=Zpi} Mode2{CharImp=Zpi} Mode3{CharImp=Zpi} Mode4{CharImp=Zpi}} PhaseDelay=UseScanAngle Phi=0deg Theta=theta_inc LatticeAVector{(-0.16, -0.16, -1) -> (0.16, -0.16, -1)} LatticeBVector{(-0.16, -0.16, -1) -> (-0.16, 0.16, -1)} ModesCalculator{Frequency=1GHz PhiStart=0deg PhiStop=0deg PhiStep=0deg ThetaStart=0deg ThetaStop=0deg ThetaStep=0deg} ModesList{Mode{ModeNumber=1 IndexM=0 IndexN=0 KC2=0 PropagationState=Undefined Attenuation=0 PolarizationState=TE AffectsRefinement} Mode{ModeNumber=2 IndexM=0 IndexN=0 KC2=0 PropagationState=Undefined Attenuation=0 PolarizationState=TM AffectsRefinement} Mode{ModeNumber=3 IndexM=-1 IndexN=0 KC2=385531421917553 PropagationState=Undefined Attenuation=1.7054704e+08 PolarizationState=TE AffectsRefinement} Mode{ModeNumber=4 IndexM=0 IndexN=-1 KC2=385531421917553 PropagationState=Undefined Attenuation=1.7054704e+08 PolarizationState=TE AffectsRefinement}}
setups:
  Setup1: HfssDriven Frequency=666.2THz MaxDeltaS=0.01 MaximumPasses=15 MinimumPasses=1 MinimumConvergedPasses=1 PercentRefinement=30 BasisOrder=1 PortAccuracy=2 DrivenSolverType="Direct Solver"
    sweep Varredura: 187.4THz to 666.2THz, 401 points; Type=Interpolating InterpTolerance=0.5 InterpMaxSolns=250 PassivityErrorTolerance=0.0001
source amplitudes:
  FloquetCima:1: 1W 0deg
  FloquetCima:2, FloquetCima:3, FloquetCima:4, FloquetBaixo:1..FloquetBaixo:4: 0W 0deg

design G0224_anelC (HFSS, HFSS Modal Network, model units um)
variables:
  theta_inc = 0deg
geometry:
  Au_anelc [Au_JC] = cylinder(axis=Z, base_centre=(0um, 0um, 0um), radius=0.063um, height=0.03um)
  Au_anelc_furo = cylinder(axis=Z, base_centre=(0um, 0um, 0um), radius=0.046um, height=0.03um)
  Au_anelc.subtract(Au_anelc_furo)
  Air_Domain [vacuum] = box(corner=(-0.16um, -0.16um, -1um), size=(0.32um, 0.32um, 2.03um))
  Au_anelc_1 = Au_anelc.copy()
  Air_Domain.subtract(Au_anelc_1)
boundaries and excitations:
  LatticePair_O017ZR: Lattice Pair Faces=Air_Domain.face(-x, +x) CoordSysVector{(-0.16, -0.16, -1) -> (-0.16, -0.16, 1.03)} PhaseDelay=UseScanAngle Phi=0deg Theta=theta_inc
  LatticePair_66Y4NK: Lattice Pair Faces=Air_Domain.face(-y, +y) CoordSysVector{(0.16, -0.16, -1) -> (0.16, -0.16, 1.03)} PhaseDelay=UseScanAngle Phi=0deg Theta=theta_inc
  FloquetCima: Floquet Port Faces=Air_Domain.face(+z) NumModes=4 Modes{Mode1{CharImp=Zpi} Mode2{CharImp=Zpi} Mode3{CharImp=Zpi} Mode4{CharImp=Zpi}} PhaseDelay=UseScanAngle Phi=0deg Theta=theta_inc LatticeAVector{(-0.16, -0.16, 1.03) -> (0.16, -0.16, 1.03)} LatticeBVector{(-0.16, -0.16, 1.03) -> (-0.16, 0.16, 1.03)} ModesCalculator{Frequency=1GHz PhiStart=0deg PhiStop=0deg PhiStep=0deg ThetaStart=0deg ThetaStop=0deg ThetaStep=0deg} ModesList{Mode{ModeNumber=1 IndexM=0 IndexN=0 KC2=0 PropagationState=Undefined Attenuation=0 PolarizationState=TE AffectsRefinement} Mode{ModeNumber=2 IndexM=0 IndexN=0 KC2=0 PropagationState=Undefined Attenuation=0 PolarizationState=TM AffectsRefinement} Mode{ModeNumber=3 IndexM=-1 IndexN=0 KC2=385531421917553 PropagationState=Undefined Attenuation=1.7054704e+08 PolarizationState=TE AffectsRefinement} Mode{ModeNumber=4 IndexM=0 IndexN=-1 KC2=385531421917553 PropagationState=Undefined Attenuation=1.7054704e+08 PolarizationState=TE AffectsRefinement}}
  FloquetBaixo: Floquet Port Faces=Air_Domain.face(-z) NumModes=4 Modes{Mode1{CharImp=Zpi} Mode2{CharImp=Zpi} Mode3{CharImp=Zpi} Mode4{CharImp=Zpi}} PhaseDelay=UseScanAngle Phi=0deg Theta=theta_inc LatticeAVector{(-0.16, -0.16, -1) -> (0.16, -0.16, -1)} LatticeBVector{(-0.16, -0.16, -1) -> (-0.16, 0.16, -1)} ModesCalculator{Frequency=1GHz PhiStart=0deg PhiStop=0deg PhiStep=0deg ThetaStart=0deg ThetaStop=0deg ThetaStep=0deg} ModesList{Mode{ModeNumber=1 IndexM=0 IndexN=0 KC2=0 PropagationState=Undefined Attenuation=0 PolarizationState=TE AffectsRefinement} Mode{ModeNumber=2 IndexM=0 IndexN=0 KC2=0 PropagationState=Undefined Attenuation=0 PolarizationState=TM AffectsRefinement} Mode{ModeNumber=3 IndexM=-1 IndexN=0 KC2=385531421917553 PropagationState=Undefined Attenuation=1.7054704e+08 PolarizationState=TE AffectsRefinement} Mode{ModeNumber=4 IndexM=0 IndexN=-1 KC2=385531421917553 PropagationState=Undefined Attenuation=1.7054704e+08 PolarizationState=TE AffectsRefinement}}
setups:
  Setup1: HfssDriven Frequency=666.2THz MaxDeltaS=0.01 MaximumPasses=15 MinimumPasses=1 MinimumConvergedPasses=1 PercentRefinement=30 BasisOrder=1 PortAccuracy=2 DrivenSolverType="Direct Solver"
    sweep Varredura: 187.4THz to 666.2THz, 401 points; Type=Interpolating InterpTolerance=0.5 InterpMaxSolns=250 PassivityErrorTolerance=0.0001
source amplitudes:
  FloquetCima:1: 1W 0deg
  FloquetCima:2, FloquetCima:3, FloquetCima:4, FloquetBaixo:1..FloquetBaixo:4: 0W 0deg

design G0228_anelC (HFSS, HFSS Modal Network, model units um)
variables:
  theta_inc = 0deg
geometry:
  Au_anelc [Au_JC] = cylinder(axis=Z, base_centre=(0um, 0um, 0um), radius=0.042um, height=0.03um)
  Au_anelc_furo = cylinder(axis=Z, base_centre=(0um, 0um, 0um), radius=0.026um, height=0.03um)
  Au_anelc.subtract(Au_anelc_furo)
  Air_Domain [vacuum] = box(corner=(-0.16um, -0.16um, -1um), size=(0.32um, 0.32um, 2.03um))
  Au_anelc_1 = Au_anelc.copy()
  Air_Domain.subtract(Au_anelc_1)
boundaries and excitations:
  LatticePair_G77NWY: Lattice Pair Faces=Air_Domain.face(-x, +x) CoordSysVector{(-0.16, -0.16, -1) -> (-0.16, -0.16, 1.03)} PhaseDelay=UseScanAngle Phi=0deg Theta=theta_inc
  LatticePair_YCUR5O: Lattice Pair Faces=Air_Domain.face(-y, +y) CoordSysVector{(0.16, -0.16, -1) -> (0.16, -0.16, 1.03)} PhaseDelay=UseScanAngle Phi=0deg Theta=theta_inc
  FloquetCima: Floquet Port Faces=Air_Domain.face(+z) NumModes=4 Modes{Mode1{CharImp=Zpi} Mode2{CharImp=Zpi} Mode3{CharImp=Zpi} Mode4{CharImp=Zpi}} PhaseDelay=UseScanAngle Phi=0deg Theta=theta_inc LatticeAVector{(-0.16, -0.16, 1.03) -> (0.16, -0.16, 1.03)} LatticeBVector{(-0.16, -0.16, 1.03) -> (-0.16, 0.16, 1.03)} ModesCalculator{Frequency=1GHz PhiStart=0deg PhiStop=0deg PhiStep=0deg ThetaStart=0deg ThetaStop=0deg ThetaStep=0deg} ModesList{Mode{ModeNumber=1 IndexM=0 IndexN=0 KC2=0 PropagationState=Undefined Attenuation=0 PolarizationState=TE AffectsRefinement} Mode{ModeNumber=2 IndexM=0 IndexN=0 KC2=0 PropagationState=Undefined Attenuation=0 PolarizationState=TM AffectsRefinement} Mode{ModeNumber=3 IndexM=-1 IndexN=0 KC2=385531421917553 PropagationState=Undefined Attenuation=1.7054704e+08 PolarizationState=TE AffectsRefinement} Mode{ModeNumber=4 IndexM=0 IndexN=-1 KC2=385531421917553 PropagationState=Undefined Attenuation=1.7054704e+08 PolarizationState=TE AffectsRefinement}}
  FloquetBaixo: Floquet Port Faces=Air_Domain.face(-z) NumModes=4 Modes{Mode1{CharImp=Zpi} Mode2{CharImp=Zpi} Mode3{CharImp=Zpi} Mode4{CharImp=Zpi}} PhaseDelay=UseScanAngle Phi=0deg Theta=theta_inc LatticeAVector{(-0.16, -0.16, -1) -> (0.16, -0.16, -1)} LatticeBVector{(-0.16, -0.16, -1) -> (-0.16, 0.16, -1)} ModesCalculator{Frequency=1GHz PhiStart=0deg PhiStop=0deg PhiStep=0deg ThetaStart=0deg ThetaStop=0deg ThetaStep=0deg} ModesList{Mode{ModeNumber=1 IndexM=0 IndexN=0 KC2=0 PropagationState=Undefined Attenuation=0 PolarizationState=TE AffectsRefinement} Mode{ModeNumber=2 IndexM=0 IndexN=0 KC2=0 PropagationState=Undefined Attenuation=0 PolarizationState=TM AffectsRefinement} Mode{ModeNumber=3 IndexM=-1 IndexN=0 KC2=385531421917553 PropagationState=Undefined Attenuation=1.7054704e+08 PolarizationState=TE AffectsRefinement} Mode{ModeNumber=4 IndexM=0 IndexN=-1 KC2=385531421917553 PropagationState=Undefined Attenuation=1.7054704e+08 PolarizationState=TE AffectsRefinement}}
setups:
  Setup1: HfssDriven Frequency=666.2THz MaxDeltaS=0.01 MaximumPasses=15 MinimumPasses=1 MinimumConvergedPasses=1 PercentRefinement=30 BasisOrder=1 PortAccuracy=2 DrivenSolverType="Direct Solver"
    sweep Varredura: 187.4THz to 666.2THz, 401 points; Type=Interpolating InterpTolerance=0.5 InterpMaxSolns=250 PassivityErrorTolerance=0.0001
source amplitudes:
  FloquetCima:1: 1W 0deg
  FloquetCima:2, FloquetCima:3, FloquetCima:4, FloquetBaixo:1..FloquetBaixo:4: 0W 0deg

design G0285_anelC (HFSS, HFSS Modal Network, model units um)
variables:
  theta_inc = 0deg
geometry:
  Au_anelc [Au_JC] = cylinder(axis=Z, base_centre=(0um, 0um, 0um), radius=0.042um, height=0.03um)
  Au_anelc_furo = cylinder(axis=Z, base_centre=(0um, 0um, 0um), radius=0.024um, height=0.03um)
  Au_anelc.subtract(Au_anelc_furo)
  Air_Domain [vacuum] = box(corner=(-0.16um, -0.16um, -1um), size=(0.32um, 0.32um, 2.03um))
  Au_anelc_1 = Au_anelc.copy()
  Air_Domain.subtract(Au_anelc_1)
boundaries and excitations:
  LatticePair_M370OL: Lattice Pair Faces=Air_Domain.face(-x, +x) CoordSysVector{(-0.16, -0.16, -1) -> (-0.16, -0.16, 1.03)} PhaseDelay=UseScanAngle Phi=0deg Theta=theta_inc
  LatticePair_APBREG: Lattice Pair Faces=Air_Domain.face(-y, +y) CoordSysVector{(0.16, -0.16, -1) -> (0.16, -0.16, 1.03)} PhaseDelay=UseScanAngle Phi=0deg Theta=theta_inc
  FloquetCima: Floquet Port Faces=Air_Domain.face(+z) NumModes=4 Modes{Mode1{CharImp=Zpi} Mode2{CharImp=Zpi} Mode3{CharImp=Zpi} Mode4{CharImp=Zpi}} PhaseDelay=UseScanAngle Phi=0deg Theta=theta_inc LatticeAVector{(-0.16, -0.16, 1.03) -> (0.16, -0.16, 1.03)} LatticeBVector{(-0.16, -0.16, 1.03) -> (-0.16, 0.16, 1.03)} ModesCalculator{Frequency=1GHz PhiStart=0deg PhiStop=0deg PhiStep=0deg ThetaStart=0deg ThetaStop=0deg ThetaStep=0deg} ModesList{Mode{ModeNumber=1 IndexM=0 IndexN=0 KC2=0 PropagationState=Undefined Attenuation=0 PolarizationState=TE AffectsRefinement} Mode{ModeNumber=2 IndexM=0 IndexN=0 KC2=0 PropagationState=Undefined Attenuation=0 PolarizationState=TM AffectsRefinement} Mode{ModeNumber=3 IndexM=-1 IndexN=0 KC2=385531421917553 PropagationState=Undefined Attenuation=1.7054704e+08 PolarizationState=TE AffectsRefinement} Mode{ModeNumber=4 IndexM=0 IndexN=-1 KC2=385531421917553 PropagationState=Undefined Attenuation=1.7054704e+08 PolarizationState=TE AffectsRefinement}}
  FloquetBaixo: Floquet Port Faces=Air_Domain.face(-z) NumModes=4 Modes{Mode1{CharImp=Zpi} Mode2{CharImp=Zpi} Mode3{CharImp=Zpi} Mode4{CharImp=Zpi}} PhaseDelay=UseScanAngle Phi=0deg Theta=theta_inc LatticeAVector{(-0.16, -0.16, -1) -> (0.16, -0.16, -1)} LatticeBVector{(-0.16, -0.16, -1) -> (-0.16, 0.16, -1)} ModesCalculator{Frequency=1GHz PhiStart=0deg PhiStop=0deg PhiStep=0deg ThetaStart=0deg ThetaStop=0deg ThetaStep=0deg} ModesList{Mode{ModeNumber=1 IndexM=0 IndexN=0 KC2=0 PropagationState=Undefined Attenuation=0 PolarizationState=TE AffectsRefinement} Mode{ModeNumber=2 IndexM=0 IndexN=0 KC2=0 PropagationState=Undefined Attenuation=0 PolarizationState=TM AffectsRefinement} Mode{ModeNumber=3 IndexM=-1 IndexN=0 KC2=385531421917553 PropagationState=Undefined Attenuation=1.7054704e+08 PolarizationState=TE AffectsRefinement} Mode{ModeNumber=4 IndexM=0 IndexN=-1 KC2=385531421917553 PropagationState=Undefined Attenuation=1.7054704e+08 PolarizationState=TE AffectsRefinement}}
setups:
  Setup1: HfssDriven Frequency=666.2THz MaxDeltaS=0.01 MaximumPasses=15 MinimumPasses=1 MinimumConvergedPasses=1 PercentRefinement=30 BasisOrder=1 PortAccuracy=2 DrivenSolverType="Direct Solver"
    sweep Varredura: 187.4THz to 666.2THz, 401 points; Type=Interpolating InterpTolerance=0.5 InterpMaxSolns=250 PassivityErrorTolerance=0.0001
source amplitudes:
  FloquetCima:1: 1W 0deg
  FloquetCima:2, FloquetCima:3, FloquetCima:4, FloquetBaixo:1..FloquetBaixo:4: 0W 0deg

design G0230_anelC (HFSS, HFSS Modal Network, model units um)
variables:
  theta_inc = 0deg
geometry:
  Au_anelc [Au_JC] = cylinder(axis=Z, base_centre=(0um, 0um, 0um), radius=0.124um, height=0.03um)
  Au_anelc_furo = cylinder(axis=Z, base_centre=(0um, 0um, 0um), radius=0.097um, height=0.03um)
  Au_anelc.subtract(Au_anelc_furo)
  Air_Domain [vacuum] = box(corner=(-0.16um, -0.16um, -1um), size=(0.32um, 0.32um, 2.03um))
  Au_anelc_1 = Au_anelc.copy()
  Air_Domain.subtract(Au_anelc_1)
boundaries and excitations:
  LatticePair_3FF4TK: Lattice Pair Faces=Air_Domain.face(-x, +x) CoordSysVector{(-0.16, -0.16, -1) -> (-0.16, -0.16, 1.03)} PhaseDelay=UseScanAngle Phi=0deg Theta=theta_inc
  LatticePair_7CT24G: Lattice Pair Faces=Air_Domain.face(-y, +y) CoordSysVector{(0.16, -0.16, -1) -> (0.16, -0.16, 1.03)} PhaseDelay=UseScanAngle Phi=0deg Theta=theta_inc
  FloquetCima: Floquet Port Faces=Air_Domain.face(+z) NumModes=4 Modes{Mode1{CharImp=Zpi} Mode2{CharImp=Zpi} Mode3{CharImp=Zpi} Mode4{CharImp=Zpi}} PhaseDelay=UseScanAngle Phi=0deg Theta=theta_inc LatticeAVector{(-0.16, -0.16, 1.03) -> (0.16, -0.16, 1.03)} LatticeBVector{(-0.16, -0.16, 1.03) -> (-0.16, 0.16, 1.03)} ModesCalculator{Frequency=1GHz PhiStart=0deg PhiStop=0deg PhiStep=0deg ThetaStart=0deg ThetaStop=0deg ThetaStep=0deg} ModesList{Mode{ModeNumber=1 IndexM=0 IndexN=0 KC2=0 PropagationState=Undefined Attenuation=0 PolarizationState=TE AffectsRefinement} Mode{ModeNumber=2 IndexM=0 IndexN=0 KC2=0 PropagationState=Undefined Attenuation=0 PolarizationState=TM AffectsRefinement} Mode{ModeNumber=3 IndexM=-1 IndexN=0 KC2=385531421917553 PropagationState=Undefined Attenuation=1.7054704e+08 PolarizationState=TE AffectsRefinement} Mode{ModeNumber=4 IndexM=0 IndexN=-1 KC2=385531421917553 PropagationState=Undefined Attenuation=1.7054704e+08 PolarizationState=TE AffectsRefinement}}
  FloquetBaixo: Floquet Port Faces=Air_Domain.face(-z) NumModes=4 Modes{Mode1{CharImp=Zpi} Mode2{CharImp=Zpi} Mode3{CharImp=Zpi} Mode4{CharImp=Zpi}} PhaseDelay=UseScanAngle Phi=0deg Theta=theta_inc LatticeAVector{(-0.16, -0.16, -1) -> (0.16, -0.16, -1)} LatticeBVector{(-0.16, -0.16, -1) -> (-0.16, 0.16, -1)} ModesCalculator{Frequency=1GHz PhiStart=0deg PhiStop=0deg PhiStep=0deg ThetaStart=0deg ThetaStop=0deg ThetaStep=0deg} ModesList{Mode{ModeNumber=1 IndexM=0 IndexN=0 KC2=0 PropagationState=Undefined Attenuation=0 PolarizationState=TE AffectsRefinement} Mode{ModeNumber=2 IndexM=0 IndexN=0 KC2=0 PropagationState=Undefined Attenuation=0 PolarizationState=TM AffectsRefinement} Mode{ModeNumber=3 IndexM=-1 IndexN=0 KC2=385531421917553 PropagationState=Undefined Attenuation=1.7054704e+08 PolarizationState=TE AffectsRefinement} Mode{ModeNumber=4 IndexM=0 IndexN=-1 KC2=385531421917553 PropagationState=Undefined Attenuation=1.7054704e+08 PolarizationState=TE AffectsRefinement}}
setups:
  Setup1: HfssDriven Frequency=666.2THz MaxDeltaS=0.01 MaximumPasses=15 MinimumPasses=1 MinimumConvergedPasses=1 PercentRefinement=30 BasisOrder=1 PortAccuracy=2 DrivenSolverType="Direct Solver"
    sweep Varredura: 187.4THz to 666.2THz, 401 points; Type=Interpolating InterpTolerance=0.5 InterpMaxSolns=250 PassivityErrorTolerance=0.0001
source amplitudes:
  FloquetCima:1: 1W 0deg
  FloquetCima:2, FloquetCima:3, FloquetCima:4, FloquetBaixo:1..FloquetBaixo:4: 0W 0deg

design G0283_anelC (HFSS, HFSS Modal Network, model units um)
variables:
  theta_inc = 0deg
geometry:
  Au_anelc [Au_JC] = cylinder(axis=Z, base_centre=(0um, 0um, 0um), radius=0.106um, height=0.03um)
  Au_anelc_furo = cylinder(axis=Z, base_centre=(0um, 0um, 0um), radius=0.086um, height=0.03um)
  Au_anelc.subtract(Au_anelc_furo)
  Air_Domain [vacuum] = box(corner=(-0.16um, -0.16um, -1um), size=(0.32um, 0.32um, 2.03um))
  Au_anelc_1 = Au_anelc.copy()
  Air_Domain.subtract(Au_anelc_1)
boundaries and excitations:
  LatticePair_PE9ABX: Lattice Pair Faces=Air_Domain.face(-x, +x) CoordSysVector{(-0.16, -0.16, -1) -> (-0.16, -0.16, 1.03)} PhaseDelay=UseScanAngle Phi=0deg Theta=theta_inc
  LatticePair_ET9LAV: Lattice Pair Faces=Air_Domain.face(-y, +y) CoordSysVector{(0.16, -0.16, -1) -> (0.16, -0.16, 1.03)} PhaseDelay=UseScanAngle Phi=0deg Theta=theta_inc
  FloquetCima: Floquet Port Faces=Air_Domain.face(+z) NumModes=4 Modes{Mode1{CharImp=Zpi} Mode2{CharImp=Zpi} Mode3{CharImp=Zpi} Mode4{CharImp=Zpi}} PhaseDelay=UseScanAngle Phi=0deg Theta=theta_inc LatticeAVector{(-0.16, -0.16, 1.03) -> (0.16, -0.16, 1.03)} LatticeBVector{(-0.16, -0.16, 1.03) -> (-0.16, 0.16, 1.03)} ModesCalculator{Frequency=1GHz PhiStart=0deg PhiStop=0deg PhiStep=0deg ThetaStart=0deg ThetaStop=0deg ThetaStep=0deg} ModesList{Mode{ModeNumber=1 IndexM=0 IndexN=0 KC2=0 PropagationState=Undefined Attenuation=0 PolarizationState=TE AffectsRefinement} Mode{ModeNumber=2 IndexM=0 IndexN=0 KC2=0 PropagationState=Undefined Attenuation=0 PolarizationState=TM AffectsRefinement} Mode{ModeNumber=3 IndexM=-1 IndexN=0 KC2=385531421917553 PropagationState=Undefined Attenuation=1.7054704e+08 PolarizationState=TE AffectsRefinement} Mode{ModeNumber=4 IndexM=0 IndexN=-1 KC2=385531421917553 PropagationState=Undefined Attenuation=1.7054704e+08 PolarizationState=TE AffectsRefinement}}
  FloquetBaixo: Floquet Port Faces=Air_Domain.face(-z) NumModes=4 Modes{Mode1{CharImp=Zpi} Mode2{CharImp=Zpi} Mode3{CharImp=Zpi} Mode4{CharImp=Zpi}} PhaseDelay=UseScanAngle Phi=0deg Theta=theta_inc LatticeAVector{(-0.16, -0.16, -1) -> (0.16, -0.16, -1)} LatticeBVector{(-0.16, -0.16, -1) -> (-0.16, 0.16, -1)} ModesCalculator{Frequency=1GHz PhiStart=0deg PhiStop=0deg PhiStep=0deg ThetaStart=0deg ThetaStop=0deg ThetaStep=0deg} ModesList{Mode{ModeNumber=1 IndexM=0 IndexN=0 KC2=0 PropagationState=Undefined Attenuation=0 PolarizationState=TE AffectsRefinement} Mode{ModeNumber=2 IndexM=0 IndexN=0 KC2=0 PropagationState=Undefined Attenuation=0 PolarizationState=TM AffectsRefinement} Mode{ModeNumber=3 IndexM=-1 IndexN=0 KC2=385531421917553 PropagationState=Undefined Attenuation=1.7054704e+08 PolarizationState=TE AffectsRefinement} Mode{ModeNumber=4 IndexM=0 IndexN=-1 KC2=385531421917553 PropagationState=Undefined Attenuation=1.7054704e+08 PolarizationState=TE AffectsRefinement}}
setups:
  Setup1: HfssDriven Frequency=666.2THz MaxDeltaS=0.01 MaximumPasses=15 MinimumPasses=1 MinimumConvergedPasses=1 PercentRefinement=30 BasisOrder=1 PortAccuracy=2 DrivenSolverType="Direct Solver"
    sweep Varredura: 187.4THz to 666.2THz, 401 points; Type=Interpolating InterpTolerance=0.5 InterpMaxSolns=250 PassivityErrorTolerance=0.0001
source amplitudes:
  FloquetCima:1: 1W 0deg
  FloquetCima:2, FloquetCima:3, FloquetCima:4, FloquetBaixo:1..FloquetBaixo:4: 0W 0deg

design G0299_anelC (HFSS, HFSS Modal Network, model units um)
variables:
  theta_inc = 0deg
geometry:
  Au_anelc [Au_JC] = cylinder(axis=Z, base_centre=(0um, 0um, 0um), radius=0.083um, height=0.03um)
  Au_anelc_furo = cylinder(axis=Z, base_centre=(0um, 0um, 0um), radius=0.053um, height=0.03um)
  Au_anelc.subtract(Au_anelc_furo)
  Air_Domain [vacuum] = box(corner=(-0.16um, -0.16um, -1um), size=(0.32um, 0.32um, 2.03um))
  Au_anelc_1 = Au_anelc.copy()
  Air_Domain.subtract(Au_anelc_1)
boundaries and excitations:
  LatticePair_T4IETD: Lattice Pair Faces=Air_Domain.face(-x, +x) CoordSysVector{(-0.16, -0.16, -1) -> (-0.16, -0.16, 1.03)} PhaseDelay=UseScanAngle Phi=0deg Theta=theta_inc
  LatticePair_XUGZRR: Lattice Pair Faces=Air_Domain.face(-y, +y) CoordSysVector{(0.16, -0.16, -1) -> (0.16, -0.16, 1.03)} PhaseDelay=UseScanAngle Phi=0deg Theta=theta_inc
  FloquetCima: Floquet Port Faces=Air_Domain.face(+z) NumModes=4 Modes{Mode1{CharImp=Zpi} Mode2{CharImp=Zpi} Mode3{CharImp=Zpi} Mode4{CharImp=Zpi}} PhaseDelay=UseScanAngle Phi=0deg Theta=theta_inc LatticeAVector{(-0.16, -0.16, 1.03) -> (0.16, -0.16, 1.03)} LatticeBVector{(-0.16, -0.16, 1.03) -> (-0.16, 0.16, 1.03)} ModesCalculator{Frequency=1GHz PhiStart=0deg PhiStop=0deg PhiStep=0deg ThetaStart=0deg ThetaStop=0deg ThetaStep=0deg} ModesList{Mode{ModeNumber=1 IndexM=0 IndexN=0 KC2=0 PropagationState=Undefined Attenuation=0 PolarizationState=TE AffectsRefinement} Mode{ModeNumber=2 IndexM=0 IndexN=0 KC2=0 PropagationState=Undefined Attenuation=0 PolarizationState=TM AffectsRefinement} Mode{ModeNumber=3 IndexM=-1 IndexN=0 KC2=385531421917553 PropagationState=Undefined Attenuation=1.7054704e+08 PolarizationState=TE AffectsRefinement} Mode{ModeNumber=4 IndexM=0 IndexN=-1 KC2=385531421917553 PropagationState=Undefined Attenuation=1.7054704e+08 PolarizationState=TE AffectsRefinement}}
  FloquetBaixo: Floquet Port Faces=Air_Domain.face(-z) NumModes=4 Modes{Mode1{CharImp=Zpi} Mode2{CharImp=Zpi} Mode3{CharImp=Zpi} Mode4{CharImp=Zpi}} PhaseDelay=UseScanAngle Phi=0deg Theta=theta_inc LatticeAVector{(-0.16, -0.16, -1) -> (0.16, -0.16, -1)} LatticeBVector{(-0.16, -0.16, -1) -> (-0.16, 0.16, -1)} ModesCalculator{Frequency=1GHz PhiStart=0deg PhiStop=0deg PhiStep=0deg ThetaStart=0deg ThetaStop=0deg ThetaStep=0deg} ModesList{Mode{ModeNumber=1 IndexM=0 IndexN=0 KC2=0 PropagationState=Undefined Attenuation=0 PolarizationState=TE AffectsRefinement} Mode{ModeNumber=2 IndexM=0 IndexN=0 KC2=0 PropagationState=Undefined Attenuation=0 PolarizationState=TM AffectsRefinement} Mode{ModeNumber=3 IndexM=-1 IndexN=0 KC2=385531421917553 PropagationState=Undefined Attenuation=1.7054704e+08 PolarizationState=TE AffectsRefinement} Mode{ModeNumber=4 IndexM=0 IndexN=-1 KC2=385531421917553 PropagationState=Undefined Attenuation=1.7054704e+08 PolarizationState=TE AffectsRefinement}}
setups:
  Setup1: HfssDriven Frequency=666.2THz MaxDeltaS=0.01 MaximumPasses=15 MinimumPasses=1 MinimumConvergedPasses=1 PercentRefinement=30 BasisOrder=1 PortAccuracy=2 DrivenSolverType="Direct Solver"
    sweep Varredura: 187.4THz to 666.2THz, 401 points; Type=Interpolating InterpTolerance=0.5 InterpMaxSolns=250 PassivityErrorTolerance=0.0001
source amplitudes:
  FloquetCima:1: 1W 0deg
  FloquetCima:2, FloquetCima:3, FloquetCima:4, FloquetBaixo:1..FloquetBaixo:4: 0W 0deg

design G0277_anelC (HFSS, HFSS Modal Network, model units um)
variables:
  theta_inc = 0deg
geometry:
  Au_anelc [Au_JC] = cylinder(axis=Z, base_centre=(0um, 0um, 0um), radius=0.057um, height=0.03um)
  Au_anelc_furo = cylinder(axis=Z, base_centre=(0um, 0um, 0um), radius=0.025um, height=0.03um)
  Au_anelc.subtract(Au_anelc_furo)
  Air_Domain [vacuum] = box(corner=(-0.16um, -0.16um, -1um), size=(0.32um, 0.32um, 2.03um))
  Au_anelc_1 = Au_anelc.copy()
  Air_Domain.subtract(Au_anelc_1)
boundaries and excitations:
  LatticePair_EFX7TR: Lattice Pair Faces=Air_Domain.face(-x, +x) CoordSysVector{(-0.16, -0.16, -1) -> (-0.16, -0.16, 1.03)} PhaseDelay=UseScanAngle Phi=0deg Theta=theta_inc
  LatticePair_18YWDV: Lattice Pair Faces=Air_Domain.face(-y, +y) CoordSysVector{(0.16, -0.16, -1) -> (0.16, -0.16, 1.03)} PhaseDelay=UseScanAngle Phi=0deg Theta=theta_inc
  FloquetCima: Floquet Port Faces=Air_Domain.face(+z) NumModes=4 Modes{Mode1{CharImp=Zpi} Mode2{CharImp=Zpi} Mode3{CharImp=Zpi} Mode4{CharImp=Zpi}} PhaseDelay=UseScanAngle Phi=0deg Theta=theta_inc LatticeAVector{(-0.16, -0.16, 1.03) -> (0.16, -0.16, 1.03)} LatticeBVector{(-0.16, -0.16, 1.03) -> (-0.16, 0.16, 1.03)} ModesCalculator{Frequency=1GHz PhiStart=0deg PhiStop=0deg PhiStep=0deg ThetaStart=0deg ThetaStop=0deg ThetaStep=0deg} ModesList{Mode{ModeNumber=1 IndexM=0 IndexN=0 KC2=0 PropagationState=Undefined Attenuation=0 PolarizationState=TE AffectsRefinement} Mode{ModeNumber=2 IndexM=0 IndexN=0 KC2=0 PropagationState=Undefined Attenuation=0 PolarizationState=TM AffectsRefinement} Mode{ModeNumber=3 IndexM=-1 IndexN=0 KC2=385531421917553 PropagationState=Undefined Attenuation=1.7054704e+08 PolarizationState=TE AffectsRefinement} Mode{ModeNumber=4 IndexM=0 IndexN=-1 KC2=385531421917553 PropagationState=Undefined Attenuation=1.7054704e+08 PolarizationState=TE AffectsRefinement}}
  FloquetBaixo: Floquet Port Faces=Air_Domain.face(-z) NumModes=4 Modes{Mode1{CharImp=Zpi} Mode2{CharImp=Zpi} Mode3{CharImp=Zpi} Mode4{CharImp=Zpi}} PhaseDelay=UseScanAngle Phi=0deg Theta=theta_inc LatticeAVector{(-0.16, -0.16, -1) -> (0.16, -0.16, -1)} LatticeBVector{(-0.16, -0.16, -1) -> (-0.16, 0.16, -1)} ModesCalculator{Frequency=1GHz PhiStart=0deg PhiStop=0deg PhiStep=0deg ThetaStart=0deg ThetaStop=0deg ThetaStep=0deg} ModesList{Mode{ModeNumber=1 IndexM=0 IndexN=0 KC2=0 PropagationState=Undefined Attenuation=0 PolarizationState=TE AffectsRefinement} Mode{ModeNumber=2 IndexM=0 IndexN=0 KC2=0 PropagationState=Undefined Attenuation=0 PolarizationState=TM AffectsRefinement} Mode{ModeNumber=3 IndexM=-1 IndexN=0 KC2=385531421917553 PropagationState=Undefined Attenuation=1.7054704e+08 PolarizationState=TE AffectsRefinement} Mode{ModeNumber=4 IndexM=0 IndexN=-1 KC2=385531421917553 PropagationState=Undefined Attenuation=1.7054704e+08 PolarizationState=TE AffectsRefinement}}
setups:
  Setup1: HfssDriven Frequency=666.2THz MaxDeltaS=0.01 MaximumPasses=15 MinimumPasses=1 MinimumConvergedPasses=1 PercentRefinement=30 BasisOrder=1 PortAccuracy=2 DrivenSolverType="Direct Solver"
    sweep Varredura: 187.4THz to 666.2THz, 401 points; Type=Interpolating InterpTolerance=0.5 InterpMaxSolns=250 PassivityErrorTolerance=0.0001
source amplitudes:
  FloquetCima:1: 1W 0deg
  FloquetCima:2, FloquetCima:3, FloquetCima:4, FloquetBaixo:1..FloquetBaixo:4: 0W 0deg

design G0279_anelC (HFSS, HFSS Modal Network, model units um)
variables:
  theta_inc = 0deg
geometry:
  Au_anelc [Au_JC] = cylinder(axis=Z, base_centre=(0um, 0um, 0um), radius=0.126um, height=0.03um)
  Au_anelc_furo = cylinder(axis=Z, base_centre=(0um, 0um, 0um), radius=0.083um, height=0.03um)
  Au_anelc.subtract(Au_anelc_furo)
  Air_Domain [vacuum] = box(corner=(-0.16um, -0.16um, -1um), size=(0.32um, 0.32um, 2.03um))
  Au_anelc_1 = Au_anelc.copy()
  Air_Domain.subtract(Au_anelc_1)
boundaries and excitations:
  LatticePair_SXEIP9: Lattice Pair Faces=Air_Domain.face(-x, +x) CoordSysVector{(-0.16, -0.16, -1) -> (-0.16, -0.16, 1.03)} PhaseDelay=UseScanAngle Phi=0deg Theta=theta_inc
  LatticePair_G2W3HK: Lattice Pair Faces=Air_Domain.face(-y, +y) CoordSysVector{(0.16, -0.16, -1) -> (0.16, -0.16, 1.03)} PhaseDelay=UseScanAngle Phi=0deg Theta=theta_inc
  FloquetCima: Floquet Port Faces=Air_Domain.face(+z) NumModes=4 Modes{Mode1{CharImp=Zpi} Mode2{CharImp=Zpi} Mode3{CharImp=Zpi} Mode4{CharImp=Zpi}} PhaseDelay=UseScanAngle Phi=0deg Theta=theta_inc LatticeAVector{(-0.16, -0.16, 1.03) -> (0.16, -0.16, 1.03)} LatticeBVector{(-0.16, -0.16, 1.03) -> (-0.16, 0.16, 1.03)} ModesCalculator{Frequency=1GHz PhiStart=0deg PhiStop=0deg PhiStep=0deg ThetaStart=0deg ThetaStop=0deg ThetaStep=0deg} ModesList{Mode{ModeNumber=1 IndexM=0 IndexN=0 KC2=0 PropagationState=Undefined Attenuation=0 PolarizationState=TE AffectsRefinement} Mode{ModeNumber=2 IndexM=0 IndexN=0 KC2=0 PropagationState=Undefined Attenuation=0 PolarizationState=TM AffectsRefinement} Mode{ModeNumber=3 IndexM=-1 IndexN=0 KC2=385531421917553 PropagationState=Undefined Attenuation=1.7054704e+08 PolarizationState=TE AffectsRefinement} Mode{ModeNumber=4 IndexM=0 IndexN=-1 KC2=385531421917553 PropagationState=Undefined Attenuation=1.7054704e+08 PolarizationState=TE AffectsRefinement}}
  FloquetBaixo: Floquet Port Faces=Air_Domain.face(-z) NumModes=4 Modes{Mode1{CharImp=Zpi} Mode2{CharImp=Zpi} Mode3{CharImp=Zpi} Mode4{CharImp=Zpi}} PhaseDelay=UseScanAngle Phi=0deg Theta=theta_inc LatticeAVector{(-0.16, -0.16, -1) -> (0.16, -0.16, -1)} LatticeBVector{(-0.16, -0.16, -1) -> (-0.16, 0.16, -1)} ModesCalculator{Frequency=1GHz PhiStart=0deg PhiStop=0deg PhiStep=0deg ThetaStart=0deg ThetaStop=0deg ThetaStep=0deg} ModesList{Mode{ModeNumber=1 IndexM=0 IndexN=0 KC2=0 PropagationState=Undefined Attenuation=0 PolarizationState=TE AffectsRefinement} Mode{ModeNumber=2 IndexM=0 IndexN=0 KC2=0 PropagationState=Undefined Attenuation=0 PolarizationState=TM AffectsRefinement} Mode{ModeNumber=3 IndexM=-1 IndexN=0 KC2=385531421917553 PropagationState=Undefined Attenuation=1.7054704e+08 PolarizationState=TE AffectsRefinement} Mode{ModeNumber=4 IndexM=0 IndexN=-1 KC2=385531421917553 PropagationState=Undefined Attenuation=1.7054704e+08 PolarizationState=TE AffectsRefinement}}
setups:
  Setup1: HfssDriven Frequency=666.2THz MaxDeltaS=0.01 MaximumPasses=15 MinimumPasses=1 MinimumConvergedPasses=1 PercentRefinement=30 BasisOrder=1 PortAccuracy=2 DrivenSolverType="Direct Solver"
    sweep Varredura: 187.4THz to 666.2THz, 401 points; Type=Interpolating InterpTolerance=0.5 InterpMaxSolns=250 PassivityErrorTolerance=0.0001
source amplitudes:
  FloquetCima:1: 1W 0deg
  FloquetCima:2, FloquetCima:3, FloquetCima:4, FloquetBaixo:1..FloquetBaixo:4: 0W 0deg

design G0280_anelC (HFSS, HFSS Modal Network, model units um)
variables:
  theta_inc = 0deg
geometry:
  Au_anelc [Au_JC] = cylinder(axis=Z, base_centre=(0um, 0um, 0um), radius=0.115um, height=0.03um)
  Au_anelc_furo = cylinder(axis=Z, base_centre=(0um, 0um, 0um), radius=0.075um, height=0.03um)
  Au_anelc.subtract(Au_anelc_furo)
  Air_Domain [vacuum] = box(corner=(-0.16um, -0.16um, -1um), size=(0.32um, 0.32um, 2.03um))
  Au_anelc_1 = Au_anelc.copy()
  Air_Domain.subtract(Au_anelc_1)
boundaries and excitations:
  LatticePair_ER6HP2: Lattice Pair Faces=Air_Domain.face(-x, +x) CoordSysVector{(-0.16, -0.16, -1) -> (-0.16, -0.16, 1.03)} PhaseDelay=UseScanAngle Phi=0deg Theta=theta_inc
  LatticePair_RGQ8DK: Lattice Pair Faces=Air_Domain.face(-y, +y) CoordSysVector{(0.16, -0.16, -1) -> (0.16, -0.16, 1.03)} PhaseDelay=UseScanAngle Phi=0deg Theta=theta_inc
  FloquetCima: Floquet Port Faces=Air_Domain.face(+z) NumModes=4 Modes{Mode1{CharImp=Zpi} Mode2{CharImp=Zpi} Mode3{CharImp=Zpi} Mode4{CharImp=Zpi}} PhaseDelay=UseScanAngle Phi=0deg Theta=theta_inc LatticeAVector{(-0.16, -0.16, 1.03) -> (0.16, -0.16, 1.03)} LatticeBVector{(-0.16, -0.16, 1.03) -> (-0.16, 0.16, 1.03)} ModesCalculator{Frequency=1GHz PhiStart=0deg PhiStop=0deg PhiStep=0deg ThetaStart=0deg ThetaStop=0deg ThetaStep=0deg} ModesList{Mode{ModeNumber=1 IndexM=0 IndexN=0 KC2=0 PropagationState=Undefined Attenuation=0 PolarizationState=TE AffectsRefinement} Mode{ModeNumber=2 IndexM=0 IndexN=0 KC2=0 PropagationState=Undefined Attenuation=0 PolarizationState=TM AffectsRefinement} Mode{ModeNumber=3 IndexM=-1 IndexN=0 KC2=385531421917553 PropagationState=Undefined Attenuation=1.7054704e+08 PolarizationState=TE AffectsRefinement} Mode{ModeNumber=4 IndexM=0 IndexN=-1 KC2=385531421917553 PropagationState=Undefined Attenuation=1.7054704e+08 PolarizationState=TE AffectsRefinement}}
  FloquetBaixo: Floquet Port Faces=Air_Domain.face(-z) NumModes=4 Modes{Mode1{CharImp=Zpi} Mode2{CharImp=Zpi} Mode3{CharImp=Zpi} Mode4{CharImp=Zpi}} PhaseDelay=UseScanAngle Phi=0deg Theta=theta_inc LatticeAVector{(-0.16, -0.16, -1) -> (0.16, -0.16, -1)} LatticeBVector{(-0.16, -0.16, -1) -> (-0.16, 0.16, -1)} ModesCalculator{Frequency=1GHz PhiStart=0deg PhiStop=0deg PhiStep=0deg ThetaStart=0deg ThetaStop=0deg ThetaStep=0deg} ModesList{Mode{ModeNumber=1 IndexM=0 IndexN=0 KC2=0 PropagationState=Undefined Attenuation=0 PolarizationState=TE AffectsRefinement} Mode{ModeNumber=2 IndexM=0 IndexN=0 KC2=0 PropagationState=Undefined Attenuation=0 PolarizationState=TM AffectsRefinement} Mode{ModeNumber=3 IndexM=-1 IndexN=0 KC2=385531421917553 PropagationState=Undefined Attenuation=1.7054704e+08 PolarizationState=TE AffectsRefinement} Mode{ModeNumber=4 IndexM=0 IndexN=-1 KC2=385531421917553 PropagationState=Undefined Attenuation=1.7054704e+08 PolarizationState=TE AffectsRefinement}}
setups:
  Setup1: HfssDriven Frequency=666.2THz MaxDeltaS=0.01 MaximumPasses=15 MinimumPasses=1 MinimumConvergedPasses=1 PercentRefinement=30 BasisOrder=1 PortAccuracy=2 DrivenSolverType="Direct Solver"
    sweep Varredura: 187.4THz to 666.2THz, 401 points; Type=Interpolating InterpTolerance=0.5 InterpMaxSolns=250 PassivityErrorTolerance=0.0001
source amplitudes:
  FloquetCima:1: 1W 0deg
  FloquetCima:2, FloquetCima:3, FloquetCima:4, FloquetBaixo:1..FloquetBaixo:4: 0W 0deg

design G0319_anelQ (HFSS, HFSS Modal Network, model units um)
variables:
  theta_inc = 0deg
geometry:
  Au_anelq [Au_JC] = box(corner=(-0.0945um, -0.0945um, 0um), size=(0.189um, 0.189um, 0.03um))
  Au_anelq_furo = box(corner=(-0.0655um, -0.0655um, 0um), size=(0.131um, 0.131um, 0.03um))
  Au_anelq.subtract(Au_anelq_furo)
  Air_Domain [vacuum] = box(corner=(-0.16um, -0.16um, -1um), size=(0.32um, 0.32um, 2.03um))
  Au_anelq_1 = Au_anelq.copy()
  Air_Domain.subtract(Au_anelq_1)
boundaries and excitations:
  LatticePair_Y60AMH: Lattice Pair Faces=Air_Domain.face(-x, +x) CoordSysVector{(-0.16, -0.16, -1) -> (-0.16, -0.16, 1.03)} PhaseDelay=UseScanAngle Phi=0deg Theta=theta_inc
  LatticePair_0RI9U3: Lattice Pair Faces=Air_Domain.face(-y, +y) CoordSysVector{(0.16, -0.16, -1) -> (0.16, -0.16, 1.03)} PhaseDelay=UseScanAngle Phi=0deg Theta=theta_inc
  FloquetCima: Floquet Port Faces=Air_Domain.face(+z) NumModes=4 Modes{Mode1{CharImp=Zpi} Mode2{CharImp=Zpi} Mode3{CharImp=Zpi} Mode4{CharImp=Zpi}} PhaseDelay=UseScanAngle Phi=0deg Theta=theta_inc LatticeAVector{(-0.16, -0.16, 1.03) -> (0.16, -0.16, 1.03)} LatticeBVector{(-0.16, -0.16, 1.03) -> (-0.16, 0.16, 1.03)} ModesCalculator{Frequency=1GHz PhiStart=0deg PhiStop=0deg PhiStep=0deg ThetaStart=0deg ThetaStop=0deg ThetaStep=0deg} ModesList{Mode{ModeNumber=1 IndexM=0 IndexN=0 KC2=0 PropagationState=Undefined Attenuation=0 PolarizationState=TE AffectsRefinement} Mode{ModeNumber=2 IndexM=0 IndexN=0 KC2=0 PropagationState=Undefined Attenuation=0 PolarizationState=TM AffectsRefinement} Mode{ModeNumber=3 IndexM=-1 IndexN=0 KC2=385531421917553 PropagationState=Undefined Attenuation=1.7054704e+08 PolarizationState=TE AffectsRefinement} Mode{ModeNumber=4 IndexM=0 IndexN=-1 KC2=385531421917553 PropagationState=Undefined Attenuation=1.7054704e+08 PolarizationState=TE AffectsRefinement}}
  FloquetBaixo: Floquet Port Faces=Air_Domain.face(-z) NumModes=4 Modes{Mode1{CharImp=Zpi} Mode2{CharImp=Zpi} Mode3{CharImp=Zpi} Mode4{CharImp=Zpi}} PhaseDelay=UseScanAngle Phi=0deg Theta=theta_inc LatticeAVector{(-0.16, -0.16, -1) -> (0.16, -0.16, -1)} LatticeBVector{(-0.16, -0.16, -1) -> (-0.16, 0.16, -1)} ModesCalculator{Frequency=1GHz PhiStart=0deg PhiStop=0deg PhiStep=0deg ThetaStart=0deg ThetaStop=0deg ThetaStep=0deg} ModesList{Mode{ModeNumber=1 IndexM=0 IndexN=0 KC2=0 PropagationState=Undefined Attenuation=0 PolarizationState=TE AffectsRefinement} Mode{ModeNumber=2 IndexM=0 IndexN=0 KC2=0 PropagationState=Undefined Attenuation=0 PolarizationState=TM AffectsRefinement} Mode{ModeNumber=3 IndexM=-1 IndexN=0 KC2=385531421917553 PropagationState=Undefined Attenuation=1.7054704e+08 PolarizationState=TE AffectsRefinement} Mode{ModeNumber=4 IndexM=0 IndexN=-1 KC2=385531421917553 PropagationState=Undefined Attenuation=1.7054704e+08 PolarizationState=TE AffectsRefinement}}
setups:
  Setup1: HfssDriven Frequency=666.2THz MaxDeltaS=0.01 MaximumPasses=15 MinimumPasses=1 MinimumConvergedPasses=1 PercentRefinement=30 BasisOrder=1 PortAccuracy=2 DrivenSolverType="Direct Solver"
    sweep Varredura: 187.4THz to 666.2THz, 401 points; Type=Interpolating InterpTolerance=0.5 InterpMaxSolns=250 PassivityErrorTolerance=0.0001
source amplitudes:
  FloquetCima:1: 1W 0deg
  FloquetCima:2, FloquetCima:3, FloquetCima:4, FloquetBaixo:1..FloquetBaixo:4: 0W 0deg

design G0335_anelQ (HFSS, HFSS Modal Network, model units um)
variables:
  theta_inc = 0deg
geometry:
  Au_anelq [Au_JC] = box(corner=(-0.128um, -0.128um, 0um), size=(0.256um, 0.256um, 0.03um))
  Au_anelq_furo = box(corner=(-0.091um, -0.091um, 0um), size=(0.182um, 0.182um, 0.03um))
  Au_anelq.subtract(Au_anelq_furo)
  Air_Domain [vacuum] = box(corner=(-0.16um, -0.16um, -1um), size=(0.32um, 0.32um, 2.03um))
  Au_anelq_1 = Au_anelq.copy()
  Air_Domain.subtract(Au_anelq_1)
boundaries and excitations:
  LatticePair_5EF7LP: Lattice Pair Faces=Air_Domain.face(-x, +x) CoordSysVector{(-0.16, -0.16, -1) -> (-0.16, -0.16, 1.03)} PhaseDelay=UseScanAngle Phi=0deg Theta=theta_inc
  LatticePair_UM0SGW: Lattice Pair Faces=Air_Domain.face(-y, +y) CoordSysVector{(0.16, -0.16, -1) -> (0.16, -0.16, 1.03)} PhaseDelay=UseScanAngle Phi=0deg Theta=theta_inc
  FloquetCima: Floquet Port Faces=Air_Domain.face(+z) NumModes=4 Modes{Mode1{CharImp=Zpi} Mode2{CharImp=Zpi} Mode3{CharImp=Zpi} Mode4{CharImp=Zpi}} PhaseDelay=UseScanAngle Phi=0deg Theta=theta_inc LatticeAVector{(-0.16, -0.16, 1.03) -> (0.16, -0.16, 1.03)} LatticeBVector{(-0.16, -0.16, 1.03) -> (-0.16, 0.16, 1.03)} ModesCalculator{Frequency=1GHz PhiStart=0deg PhiStop=0deg PhiStep=0deg ThetaStart=0deg ThetaStop=0deg ThetaStep=0deg} ModesList{Mode{ModeNumber=1 IndexM=0 IndexN=0 KC2=0 PropagationState=Undefined Attenuation=0 PolarizationState=TE AffectsRefinement} Mode{ModeNumber=2 IndexM=0 IndexN=0 KC2=0 PropagationState=Undefined Attenuation=0 PolarizationState=TM AffectsRefinement} Mode{ModeNumber=3 IndexM=-1 IndexN=0 KC2=385531421917553 PropagationState=Undefined Attenuation=1.7054704e+08 PolarizationState=TE AffectsRefinement} Mode{ModeNumber=4 IndexM=0 IndexN=-1 KC2=385531421917553 PropagationState=Undefined Attenuation=1.7054704e+08 PolarizationState=TE AffectsRefinement}}
  FloquetBaixo: Floquet Port Faces=Air_Domain.face(-z) NumModes=4 Modes{Mode1{CharImp=Zpi} Mode2{CharImp=Zpi} Mode3{CharImp=Zpi} Mode4{CharImp=Zpi}} PhaseDelay=UseScanAngle Phi=0deg Theta=theta_inc LatticeAVector{(-0.16, -0.16, -1) -> (0.16, -0.16, -1)} LatticeBVector{(-0.16, -0.16, -1) -> (-0.16, 0.16, -1)} ModesCalculator{Frequency=1GHz PhiStart=0deg PhiStop=0deg PhiStep=0deg ThetaStart=0deg ThetaStop=0deg ThetaStep=0deg} ModesList{Mode{ModeNumber=1 IndexM=0 IndexN=0 KC2=0 PropagationState=Undefined Attenuation=0 PolarizationState=TE AffectsRefinement} Mode{ModeNumber=2 IndexM=0 IndexN=0 KC2=0 PropagationState=Undefined Attenuation=0 PolarizationState=TM AffectsRefinement} Mode{ModeNumber=3 IndexM=-1 IndexN=0 KC2=385531421917553 PropagationState=Undefined Attenuation=1.7054704e+08 PolarizationState=TE AffectsRefinement} Mode{ModeNumber=4 IndexM=0 IndexN=-1 KC2=385531421917553 PropagationState=Undefined Attenuation=1.7054704e+08 PolarizationState=TE AffectsRefinement}}
setups:
  Setup1: HfssDriven Frequency=666.2THz MaxDeltaS=0.01 MaximumPasses=15 MinimumPasses=1 MinimumConvergedPasses=1 PercentRefinement=30 BasisOrder=1 PortAccuracy=2 DrivenSolverType="Direct Solver"
    sweep Varredura: 187.4THz to 666.2THz, 401 points; Type=Interpolating InterpTolerance=0.5 InterpMaxSolns=250 PassivityErrorTolerance=0.0001
source amplitudes:
  FloquetCima:1: 1W 0deg
  FloquetCima:2, FloquetCima:3, FloquetCima:4, FloquetBaixo:1..FloquetBaixo:4: 0W 0deg

design G0323_anelQ (HFSS, HFSS Modal Network, model units um)
variables:
  theta_inc = 0deg
geometry:
  Au_anelq [Au_JC] = box(corner=(-0.1105um, -0.1105um, 0um), size=(0.221um, 0.221um, 0.03um))
  Au_anelq_furo = box(corner=(-0.0645um, -0.0645um, 0um), size=(0.129um, 0.129um, 0.03um))
  Au_anelq.subtract(Au_anelq_furo)
  Air_Domain [vacuum] = box(corner=(-0.16um, -0.16um, -1um), size=(0.32um, 0.32um, 2.03um))
  Au_anelq_1 = Au_anelq.copy()
  Air_Domain.subtract(Au_anelq_1)
boundaries and excitations:
  LatticePair_X8P62H: Lattice Pair Faces=Air_Domain.face(-x, +x) CoordSysVector{(-0.16, -0.16, -1) -> (-0.16, -0.16, 1.03)} PhaseDelay=UseScanAngle Phi=0deg Theta=theta_inc
  LatticePair_27NV9J: Lattice Pair Faces=Air_Domain.face(-y, +y) CoordSysVector{(0.16, -0.16, -1) -> (0.16, -0.16, 1.03)} PhaseDelay=UseScanAngle Phi=0deg Theta=theta_inc
  FloquetCima: Floquet Port Faces=Air_Domain.face(+z) NumModes=4 Modes{Mode1{CharImp=Zpi} Mode2{CharImp=Zpi} Mode3{CharImp=Zpi} Mode4{CharImp=Zpi}} PhaseDelay=UseScanAngle Phi=0deg Theta=theta_inc LatticeAVector{(-0.16, -0.16, 1.03) -> (0.16, -0.16, 1.03)} LatticeBVector{(-0.16, -0.16, 1.03) -> (-0.16, 0.16, 1.03)} ModesCalculator{Frequency=1GHz PhiStart=0deg PhiStop=0deg PhiStep=0deg ThetaStart=0deg ThetaStop=0deg ThetaStep=0deg} ModesList{Mode{ModeNumber=1 IndexM=0 IndexN=0 KC2=0 PropagationState=Undefined Attenuation=0 PolarizationState=TE AffectsRefinement} Mode{ModeNumber=2 IndexM=0 IndexN=0 KC2=0 PropagationState=Undefined Attenuation=0 PolarizationState=TM AffectsRefinement} Mode{ModeNumber=3 IndexM=-1 IndexN=0 KC2=385531421917553 PropagationState=Undefined Attenuation=1.7054704e+08 PolarizationState=TE AffectsRefinement} Mode{ModeNumber=4 IndexM=0 IndexN=-1 KC2=385531421917553 PropagationState=Undefined Attenuation=1.7054704e+08 PolarizationState=TE AffectsRefinement}}
  FloquetBaixo: Floquet Port Faces=Air_Domain.face(-z) NumModes=4 Modes{Mode1{CharImp=Zpi} Mode2{CharImp=Zpi} Mode3{CharImp=Zpi} Mode4{CharImp=Zpi}} PhaseDelay=UseScanAngle Phi=0deg Theta=theta_inc LatticeAVector{(-0.16, -0.16, -1) -> (0.16, -0.16, -1)} LatticeBVector{(-0.16, -0.16, -1) -> (-0.16, 0.16, -1)} ModesCalculator{Frequency=1GHz PhiStart=0deg PhiStop=0deg PhiStep=0deg ThetaStart=0deg ThetaStop=0deg ThetaStep=0deg} ModesList{Mode{ModeNumber=1 IndexM=0 IndexN=0 KC2=0 PropagationState=Undefined Attenuation=0 PolarizationState=TE AffectsRefinement} Mode{ModeNumber=2 IndexM=0 IndexN=0 KC2=0 PropagationState=Undefined Attenuation=0 PolarizationState=TM AffectsRefinement} Mode{ModeNumber=3 IndexM=-1 IndexN=0 KC2=385531421917553 PropagationState=Undefined Attenuation=1.7054704e+08 PolarizationState=TE AffectsRefinement} Mode{ModeNumber=4 IndexM=0 IndexN=-1 KC2=385531421917553 PropagationState=Undefined Attenuation=1.7054704e+08 PolarizationState=TE AffectsRefinement}}
setups:
  Setup1: HfssDriven Frequency=666.2THz MaxDeltaS=0.01 MaximumPasses=15 MinimumPasses=1 MinimumConvergedPasses=1 PercentRefinement=30 BasisOrder=1 PortAccuracy=2 DrivenSolverType="Direct Solver"
    sweep Varredura: 187.4THz to 666.2THz, 401 points; Type=Interpolating InterpTolerance=0.5 InterpMaxSolns=250 PassivityErrorTolerance=0.0001
source amplitudes:
  FloquetCima:1: 1W 0deg
  FloquetCima:2, FloquetCima:3, FloquetCima:4, FloquetBaixo:1..FloquetBaixo:4: 0W 0deg

design G0372_anelQ (HFSS, HFSS Modal Network, model units um)
variables:
  theta_inc = 0deg
geometry:
  Au_anelq [Au_JC] = box(corner=(-0.0615um, -0.0615um, 0um), size=(0.123um, 0.123um, 0.03um))
  Au_anelq_furo = box(corner=(-0.0245um, -0.0245um, 0um), size=(0.049um, 0.049um, 0.03um))
  Au_anelq.subtract(Au_anelq_furo)
  Air_Domain [vacuum] = box(corner=(-0.16um, -0.16um, -1um), size=(0.32um, 0.32um, 2.03um))
  Au_anelq_1 = Au_anelq.copy()
  Air_Domain.subtract(Au_anelq_1)
boundaries and excitations:
  LatticePair_IGLM5N: Lattice Pair Faces=Air_Domain.face(-x, +x) CoordSysVector{(-0.16, -0.16, -1) -> (-0.16, -0.16, 1.03)} PhaseDelay=UseScanAngle Phi=0deg Theta=theta_inc
  LatticePair_S1T7X4: Lattice Pair Faces=Air_Domain.face(-y, +y) CoordSysVector{(0.16, -0.16, -1) -> (0.16, -0.16, 1.03)} PhaseDelay=UseScanAngle Phi=0deg Theta=theta_inc
  FloquetCima: Floquet Port Faces=Air_Domain.face(+z) NumModes=4 Modes{Mode1{CharImp=Zpi} Mode2{CharImp=Zpi} Mode3{CharImp=Zpi} Mode4{CharImp=Zpi}} PhaseDelay=UseScanAngle Phi=0deg Theta=theta_inc LatticeAVector{(-0.16, -0.16, 1.03) -> (0.16, -0.16, 1.03)} LatticeBVector{(-0.16, -0.16, 1.03) -> (-0.16, 0.16, 1.03)} ModesCalculator{Frequency=1GHz PhiStart=0deg PhiStop=0deg PhiStep=0deg ThetaStart=0deg ThetaStop=0deg ThetaStep=0deg} ModesList{Mode{ModeNumber=1 IndexM=0 IndexN=0 KC2=0 PropagationState=Undefined Attenuation=0 PolarizationState=TE AffectsRefinement} Mode{ModeNumber=2 IndexM=0 IndexN=0 KC2=0 PropagationState=Undefined Attenuation=0 PolarizationState=TM AffectsRefinement} Mode{ModeNumber=3 IndexM=-1 IndexN=0 KC2=385531421917553 PropagationState=Undefined Attenuation=1.7054704e+08 PolarizationState=TE AffectsRefinement} Mode{ModeNumber=4 IndexM=0 IndexN=-1 KC2=385531421917553 PropagationState=Undefined Attenuation=1.7054704e+08 PolarizationState=TE AffectsRefinement}}
  FloquetBaixo: Floquet Port Faces=Air_Domain.face(-z) NumModes=4 Modes{Mode1{CharImp=Zpi} Mode2{CharImp=Zpi} Mode3{CharImp=Zpi} Mode4{CharImp=Zpi}} PhaseDelay=UseScanAngle Phi=0deg Theta=theta_inc LatticeAVector{(-0.16, -0.16, -1) -> (0.16, -0.16, -1)} LatticeBVector{(-0.16, -0.16, -1) -> (-0.16, 0.16, -1)} ModesCalculator{Frequency=1GHz PhiStart=0deg PhiStop=0deg PhiStep=0deg ThetaStart=0deg ThetaStop=0deg ThetaStep=0deg} ModesList{Mode{ModeNumber=1 IndexM=0 IndexN=0 KC2=0 PropagationState=Undefined Attenuation=0 PolarizationState=TE AffectsRefinement} Mode{ModeNumber=2 IndexM=0 IndexN=0 KC2=0 PropagationState=Undefined Attenuation=0 PolarizationState=TM AffectsRefinement} Mode{ModeNumber=3 IndexM=-1 IndexN=0 KC2=385531421917553 PropagationState=Undefined Attenuation=1.7054704e+08 PolarizationState=TE AffectsRefinement} Mode{ModeNumber=4 IndexM=0 IndexN=-1 KC2=385531421917553 PropagationState=Undefined Attenuation=1.7054704e+08 PolarizationState=TE AffectsRefinement}}
setups:
  Setup1: HfssDriven Frequency=666.2THz MaxDeltaS=0.01 MaximumPasses=15 MinimumPasses=1 MinimumConvergedPasses=1 PercentRefinement=30 BasisOrder=1 PortAccuracy=2 DrivenSolverType="Direct Solver"
    sweep Varredura: 187.4THz to 666.2THz, 401 points; Type=Interpolating InterpTolerance=0.5 InterpMaxSolns=250 PassivityErrorTolerance=0.0001
source amplitudes:
  FloquetCima:1: 1W 0deg
  FloquetCima:2, FloquetCima:3, FloquetCima:4, FloquetBaixo:1..FloquetBaixo:4: 0W 0deg

design G0344_anelQ (HFSS, HFSS Modal Network, model units um)
variables:
  theta_inc = 0deg
geometry:
  Au_anelq [Au_JC] = box(corner=(-0.0845um, -0.0845um, 0um), size=(0.169um, 0.169um, 0.03um))
  Au_anelq_furo = box(corner=(-0.0545um, -0.0545um, 0um), size=(0.109um, 0.109um, 0.03um))
  Au_anelq.subtract(Au_anelq_furo)
  Air_Domain [vacuum] = box(corner=(-0.16um, -0.16um, -1um), size=(0.32um, 0.32um, 2.03um))
  Au_anelq_1 = Au_anelq.copy()
  Air_Domain.subtract(Au_anelq_1)
boundaries and excitations:
  LatticePair_ITXZRM: Lattice Pair Faces=Air_Domain.face(-x, +x) CoordSysVector{(-0.16, -0.16, -1) -> (-0.16, -0.16, 1.03)} PhaseDelay=UseScanAngle Phi=0deg Theta=theta_inc
  LatticePair_KQJFWP: Lattice Pair Faces=Air_Domain.face(-y, +y) CoordSysVector{(0.16, -0.16, -1) -> (0.16, -0.16, 1.03)} PhaseDelay=UseScanAngle Phi=0deg Theta=theta_inc
  FloquetCima: Floquet Port Faces=Air_Domain.face(+z) NumModes=4 Modes{Mode1{CharImp=Zpi} Mode2{CharImp=Zpi} Mode3{CharImp=Zpi} Mode4{CharImp=Zpi}} PhaseDelay=UseScanAngle Phi=0deg Theta=theta_inc LatticeAVector{(-0.16, -0.16, 1.03) -> (0.16, -0.16, 1.03)} LatticeBVector{(-0.16, -0.16, 1.03) -> (-0.16, 0.16, 1.03)} ModesCalculator{Frequency=1GHz PhiStart=0deg PhiStop=0deg PhiStep=0deg ThetaStart=0deg ThetaStop=0deg ThetaStep=0deg} ModesList{Mode{ModeNumber=1 IndexM=0 IndexN=0 KC2=0 PropagationState=Undefined Attenuation=0 PolarizationState=TE AffectsRefinement} Mode{ModeNumber=2 IndexM=0 IndexN=0 KC2=0 PropagationState=Undefined Attenuation=0 PolarizationState=TM AffectsRefinement} Mode{ModeNumber=3 IndexM=-1 IndexN=0 KC2=385531421917553 PropagationState=Undefined Attenuation=1.7054704e+08 PolarizationState=TE AffectsRefinement} Mode{ModeNumber=4 IndexM=0 IndexN=-1 KC2=385531421917553 PropagationState=Undefined Attenuation=1.7054704e+08 PolarizationState=TE AffectsRefinement}}
  FloquetBaixo: Floquet Port Faces=Air_Domain.face(-z) NumModes=4 Modes{Mode1{CharImp=Zpi} Mode2{CharImp=Zpi} Mode3{CharImp=Zpi} Mode4{CharImp=Zpi}} PhaseDelay=UseScanAngle Phi=0deg Theta=theta_inc LatticeAVector{(-0.16, -0.16, -1) -> (0.16, -0.16, -1)} LatticeBVector{(-0.16, -0.16, -1) -> (-0.16, 0.16, -1)} ModesCalculator{Frequency=1GHz PhiStart=0deg PhiStop=0deg PhiStep=0deg ThetaStart=0deg ThetaStop=0deg ThetaStep=0deg} ModesList{Mode{ModeNumber=1 IndexM=0 IndexN=0 KC2=0 PropagationState=Undefined Attenuation=0 PolarizationState=TE AffectsRefinement} Mode{ModeNumber=2 IndexM=0 IndexN=0 KC2=0 PropagationState=Undefined Attenuation=0 PolarizationState=TM AffectsRefinement} Mode{ModeNumber=3 IndexM=-1 IndexN=0 KC2=385531421917553 PropagationState=Undefined Attenuation=1.7054704e+08 PolarizationState=TE AffectsRefinement} Mode{ModeNumber=4 IndexM=0 IndexN=-1 KC2=385531421917553 PropagationState=Undefined Attenuation=1.7054704e+08 PolarizationState=TE AffectsRefinement}}
setups:
  Setup1: HfssDriven Frequency=666.2THz MaxDeltaS=0.01 MaximumPasses=15 MinimumPasses=1 MinimumConvergedPasses=1 PercentRefinement=30 BasisOrder=1 PortAccuracy=2 DrivenSolverType="Direct Solver"
    sweep Varredura: 187.4THz to 666.2THz, 401 points; Type=Interpolating InterpTolerance=0.5 InterpMaxSolns=250 PassivityErrorTolerance=0.0001
source amplitudes:
  FloquetCima:1: 1W 0deg
  FloquetCima:2, FloquetCima:3, FloquetCima:4, FloquetBaixo:1..FloquetBaixo:4: 0W 0deg

design G0347_anelQ (HFSS, HFSS Modal Network, model units um)
variables:
  theta_inc = 0deg
geometry:
  Au_anelq [Au_JC] = box(corner=(-0.0775um, -0.0775um, 0um), size=(0.155um, 0.155um, 0.03um))
  Au_anelq_furo = box(corner=(-0.0475um, -0.0475um, 0um), size=(0.095um, 0.095um, 0.03um))
  Au_anelq.subtract(Au_anelq_furo)
  Air_Domain [vacuum] = box(corner=(-0.16um, -0.16um, -1um), size=(0.32um, 0.32um, 2.03um))
  Au_anelq_1 = Au_anelq.copy()
  Air_Domain.subtract(Au_anelq_1)
boundaries and excitations:
  LatticePair_CLQOR6: Lattice Pair Faces=Air_Domain.face(-x, +x) CoordSysVector{(-0.16, -0.16, -1) -> (-0.16, -0.16, 1.03)} PhaseDelay=UseScanAngle Phi=0deg Theta=theta_inc
  LatticePair_3XKRW1: Lattice Pair Faces=Air_Domain.face(-y, +y) CoordSysVector{(0.16, -0.16, -1) -> (0.16, -0.16, 1.03)} PhaseDelay=UseScanAngle Phi=0deg Theta=theta_inc
  FloquetCima: Floquet Port Faces=Air_Domain.face(+z) NumModes=4 Modes{Mode1{CharImp=Zpi} Mode2{CharImp=Zpi} Mode3{CharImp=Zpi} Mode4{CharImp=Zpi}} PhaseDelay=UseScanAngle Phi=0deg Theta=theta_inc LatticeAVector{(-0.16, -0.16, 1.03) -> (0.16, -0.16, 1.03)} LatticeBVector{(-0.16, -0.16, 1.03) -> (-0.16, 0.16, 1.03)} ModesCalculator{Frequency=1GHz PhiStart=0deg PhiStop=0deg PhiStep=0deg ThetaStart=0deg ThetaStop=0deg ThetaStep=0deg} ModesList{Mode{ModeNumber=1 IndexM=0 IndexN=0 KC2=0 PropagationState=Undefined Attenuation=0 PolarizationState=TE AffectsRefinement} Mode{ModeNumber=2 IndexM=0 IndexN=0 KC2=0 PropagationState=Undefined Attenuation=0 PolarizationState=TM AffectsRefinement} Mode{ModeNumber=3 IndexM=-1 IndexN=0 KC2=385531421917553 PropagationState=Undefined Attenuation=1.7054704e+08 PolarizationState=TE AffectsRefinement} Mode{ModeNumber=4 IndexM=0 IndexN=-1 KC2=385531421917553 PropagationState=Undefined Attenuation=1.7054704e+08 PolarizationState=TE AffectsRefinement}}
  FloquetBaixo: Floquet Port Faces=Air_Domain.face(-z) NumModes=4 Modes{Mode1{CharImp=Zpi} Mode2{CharImp=Zpi} Mode3{CharImp=Zpi} Mode4{CharImp=Zpi}} PhaseDelay=UseScanAngle Phi=0deg Theta=theta_inc LatticeAVector{(-0.16, -0.16, -1) -> (0.16, -0.16, -1)} LatticeBVector{(-0.16, -0.16, -1) -> (-0.16, 0.16, -1)} ModesCalculator{Frequency=1GHz PhiStart=0deg PhiStop=0deg PhiStep=0deg ThetaStart=0deg ThetaStop=0deg ThetaStep=0deg} ModesList{Mode{ModeNumber=1 IndexM=0 IndexN=0 KC2=0 PropagationState=Undefined Attenuation=0 PolarizationState=TE AffectsRefinement} Mode{ModeNumber=2 IndexM=0 IndexN=0 KC2=0 PropagationState=Undefined Attenuation=0 PolarizationState=TM AffectsRefinement} Mode{ModeNumber=3 IndexM=-1 IndexN=0 KC2=385531421917553 PropagationState=Undefined Attenuation=1.7054704e+08 PolarizationState=TE AffectsRefinement} Mode{ModeNumber=4 IndexM=0 IndexN=-1 KC2=385531421917553 PropagationState=Undefined Attenuation=1.7054704e+08 PolarizationState=TE AffectsRefinement}}
setups:
  Setup1: HfssDriven Frequency=666.2THz MaxDeltaS=0.01 MaximumPasses=15 MinimumPasses=1 MinimumConvergedPasses=1 PercentRefinement=30 BasisOrder=1 PortAccuracy=2 DrivenSolverType="Direct Solver"
    sweep Varredura: 187.4THz to 666.2THz, 401 points; Type=Interpolating InterpTolerance=0.5 InterpMaxSolns=250 PassivityErrorTolerance=0.0001
source amplitudes:
  FloquetCima:1: 1W 0deg
  FloquetCima:2, FloquetCima:3, FloquetCima:4, FloquetBaixo:1..FloquetBaixo:4: 0W 0deg

design G0390_anelQ (HFSS, HFSS Modal Network, model units um)
variables:
  theta_inc = 0deg
geometry:
  Au_anelq [Au_JC] = box(corner=(-0.0925um, -0.0925um, 0um), size=(0.185um, 0.185um, 0.03um))
  Au_anelq_furo = box(corner=(-0.0665um, -0.0665um, 0um), size=(0.133um, 0.133um, 0.03um))
  Au_anelq.subtract(Au_anelq_furo)
  Air_Domain [vacuum] = box(corner=(-0.16um, -0.16um, -1um), size=(0.32um, 0.32um, 2.03um))
  Au_anelq_1 = Au_anelq.copy()
  Air_Domain.subtract(Au_anelq_1)
boundaries and excitations:
  LatticePair_KSY4D3: Lattice Pair Faces=Air_Domain.face(-x, +x) CoordSysVector{(-0.16, -0.16, -1) -> (-0.16, -0.16, 1.03)} PhaseDelay=UseScanAngle Phi=0deg Theta=theta_inc
  LatticePair_O3QT6Z: Lattice Pair Faces=Air_Domain.face(-y, +y) CoordSysVector{(0.16, -0.16, -1) -> (0.16, -0.16, 1.03)} PhaseDelay=UseScanAngle Phi=0deg Theta=theta_inc
  FloquetCima: Floquet Port Faces=Air_Domain.face(+z) NumModes=4 Modes{Mode1{CharImp=Zpi} Mode2{CharImp=Zpi} Mode3{CharImp=Zpi} Mode4{CharImp=Zpi}} PhaseDelay=UseScanAngle Phi=0deg Theta=theta_inc LatticeAVector{(-0.16, -0.16, 1.03) -> (0.16, -0.16, 1.03)} LatticeBVector{(-0.16, -0.16, 1.03) -> (-0.16, 0.16, 1.03)} ModesCalculator{Frequency=1GHz PhiStart=0deg PhiStop=0deg PhiStep=0deg ThetaStart=0deg ThetaStop=0deg ThetaStep=0deg} ModesList{Mode{ModeNumber=1 IndexM=0 IndexN=0 KC2=0 PropagationState=Undefined Attenuation=0 PolarizationState=TE AffectsRefinement} Mode{ModeNumber=2 IndexM=0 IndexN=0 KC2=0 PropagationState=Undefined Attenuation=0 PolarizationState=TM AffectsRefinement} Mode{ModeNumber=3 IndexM=-1 IndexN=0 KC2=385531421917553 PropagationState=Undefined Attenuation=1.7054704e+08 PolarizationState=TE AffectsRefinement} Mode{ModeNumber=4 IndexM=0 IndexN=-1 KC2=385531421917553 PropagationState=Undefined Attenuation=1.7054704e+08 PolarizationState=TE AffectsRefinement}}
  FloquetBaixo: Floquet Port Faces=Air_Domain.face(-z) NumModes=4 Modes{Mode1{CharImp=Zpi} Mode2{CharImp=Zpi} Mode3{CharImp=Zpi} Mode4{CharImp=Zpi}} PhaseDelay=UseScanAngle Phi=0deg Theta=theta_inc LatticeAVector{(-0.16, -0.16, -1) -> (0.16, -0.16, -1)} LatticeBVector{(-0.16, -0.16, -1) -> (-0.16, 0.16, -1)} ModesCalculator{Frequency=1GHz PhiStart=0deg PhiStop=0deg PhiStep=0deg ThetaStart=0deg ThetaStop=0deg ThetaStep=0deg} ModesList{Mode{ModeNumber=1 IndexM=0 IndexN=0 KC2=0 PropagationState=Undefined Attenuation=0 PolarizationState=TE AffectsRefinement} Mode{ModeNumber=2 IndexM=0 IndexN=0 KC2=0 PropagationState=Undefined Attenuation=0 PolarizationState=TM AffectsRefinement} Mode{ModeNumber=3 IndexM=-1 IndexN=0 KC2=385531421917553 PropagationState=Undefined Attenuation=1.7054704e+08 PolarizationState=TE AffectsRefinement} Mode{ModeNumber=4 IndexM=0 IndexN=-1 KC2=385531421917553 PropagationState=Undefined Attenuation=1.7054704e+08 PolarizationState=TE AffectsRefinement}}
setups:
  Setup1: HfssDriven Frequency=666.2THz MaxDeltaS=0.01 MaximumPasses=15 MinimumPasses=1 MinimumConvergedPasses=1 PercentRefinement=30 BasisOrder=1 PortAccuracy=2 DrivenSolverType="Direct Solver"
    sweep Varredura: 187.4THz to 666.2THz, 401 points; Type=Interpolating InterpTolerance=0.5 InterpMaxSolns=250 PassivityErrorTolerance=0.0001
source amplitudes:
  FloquetCima:1: 1W 0deg
  FloquetCima:2, FloquetCima:3, FloquetCima:4, FloquetBaixo:1..FloquetBaixo:4: 0W 0deg

design G0375_anelQ (HFSS, HFSS Modal Network, model units um)
variables:
  theta_inc = 0deg
geometry:
  Au_anelq [Au_JC] = box(corner=(-0.119um, -0.119um, 0um), size=(0.238um, 0.238um, 0.03um))
  Au_anelq_furo = box(corner=(-0.087um, -0.087um, 0um), size=(0.174um, 0.174um, 0.03um))
  Au_anelq.subtract(Au_anelq_furo)
  Air_Domain [vacuum] = box(corner=(-0.16um, -0.16um, -1um), size=(0.32um, 0.32um, 2.03um))
  Au_anelq_1 = Au_anelq.copy()
  Air_Domain.subtract(Au_anelq_1)
boundaries and excitations:
  LatticePair_DIILIP: Lattice Pair Faces=Air_Domain.face(-x, +x) CoordSysVector{(-0.16, -0.16, -1) -> (-0.16, -0.16, 1.03)} PhaseDelay=UseScanAngle Phi=0deg Theta=theta_inc
  LatticePair_KRHKKS: Lattice Pair Faces=Air_Domain.face(-y, +y) CoordSysVector{(0.16, -0.16, -1) -> (0.16, -0.16, 1.03)} PhaseDelay=UseScanAngle Phi=0deg Theta=theta_inc
  FloquetCima: Floquet Port Faces=Air_Domain.face(+z) NumModes=4 Modes{Mode1{CharImp=Zpi} Mode2{CharImp=Zpi} Mode3{CharImp=Zpi} Mode4{CharImp=Zpi}} PhaseDelay=UseScanAngle Phi=0deg Theta=theta_inc LatticeAVector{(-0.16, -0.16, 1.03) -> (0.16, -0.16, 1.03)} LatticeBVector{(-0.16, -0.16, 1.03) -> (-0.16, 0.16, 1.03)} ModesCalculator{Frequency=1GHz PhiStart=0deg PhiStop=0deg PhiStep=0deg ThetaStart=0deg ThetaStop=0deg ThetaStep=0deg} ModesList{Mode{ModeNumber=1 IndexM=0 IndexN=0 KC2=0 PropagationState=Undefined Attenuation=0 PolarizationState=TE AffectsRefinement} Mode{ModeNumber=2 IndexM=0 IndexN=0 KC2=0 PropagationState=Undefined Attenuation=0 PolarizationState=TM AffectsRefinement} Mode{ModeNumber=3 IndexM=-1 IndexN=0 KC2=385531421917553 PropagationState=Undefined Attenuation=1.7054704e+08 PolarizationState=TE AffectsRefinement} Mode{ModeNumber=4 IndexM=0 IndexN=-1 KC2=385531421917553 PropagationState=Undefined Attenuation=1.7054704e+08 PolarizationState=TE AffectsRefinement}}
  FloquetBaixo: Floquet Port Faces=Air_Domain.face(-z) NumModes=4 Modes{Mode1{CharImp=Zpi} Mode2{CharImp=Zpi} Mode3{CharImp=Zpi} Mode4{CharImp=Zpi}} PhaseDelay=UseScanAngle Phi=0deg Theta=theta_inc LatticeAVector{(-0.16, -0.16, -1) -> (0.16, -0.16, -1)} LatticeBVector{(-0.16, -0.16, -1) -> (-0.16, 0.16, -1)} ModesCalculator{Frequency=1GHz PhiStart=0deg PhiStop=0deg PhiStep=0deg ThetaStart=0deg ThetaStop=0deg ThetaStep=0deg} ModesList{Mode{ModeNumber=1 IndexM=0 IndexN=0 KC2=0 PropagationState=Undefined Attenuation=0 PolarizationState=TE AffectsRefinement} Mode{ModeNumber=2 IndexM=0 IndexN=0 KC2=0 PropagationState=Undefined Attenuation=0 PolarizationState=TM AffectsRefinement} Mode{ModeNumber=3 IndexM=-1 IndexN=0 KC2=385531421917553 PropagationState=Undefined Attenuation=1.7054704e+08 PolarizationState=TE AffectsRefinement} Mode{ModeNumber=4 IndexM=0 IndexN=-1 KC2=385531421917553 PropagationState=Undefined Attenuation=1.7054704e+08 PolarizationState=TE AffectsRefinement}}
setups:
  Setup1: HfssDriven Frequency=666.2THz MaxDeltaS=0.01 MaximumPasses=15 MinimumPasses=1 MinimumConvergedPasses=1 PercentRefinement=30 BasisOrder=1 PortAccuracy=2 DrivenSolverType="Direct Solver"
    sweep Varredura: 187.4THz to 666.2THz, 401 points; Type=Interpolating InterpTolerance=0.5 InterpMaxSolns=250 PassivityErrorTolerance=0.0001
source amplitudes:
  FloquetCima:1: 1W 0deg
  FloquetCima:2, FloquetCima:3, FloquetCima:4, FloquetBaixo:1..FloquetBaixo:4: 0W 0deg

design G0351_anelQ (HFSS, HFSS Modal Network, model units um)
variables:
  theta_inc = 0deg
geometry:
  Au_anelq [Au_JC] = box(corner=(-0.0625um, -0.0625um, 0um), size=(0.125um, 0.125um, 0.03um))
  Au_anelq_furo = box(corner=(-0.0375um, -0.0375um, 0um), size=(0.075um, 0.075um, 0.03um))
  Au_anelq.subtract(Au_anelq_furo)
  Air_Domain [vacuum] = box(corner=(-0.16um, -0.16um, -1um), size=(0.32um, 0.32um, 2.03um))
  Au_anelq_1 = Au_anelq.copy()
  Air_Domain.subtract(Au_anelq_1)
boundaries and excitations:
  LatticePair_RKLZ72: Lattice Pair Faces=Air_Domain.face(-x, +x) CoordSysVector{(-0.16, -0.16, -1) -> (-0.16, -0.16, 1.03)} PhaseDelay=UseScanAngle Phi=0deg Theta=theta_inc
  LatticePair_PY5WWT: Lattice Pair Faces=Air_Domain.face(-y, +y) CoordSysVector{(0.16, -0.16, -1) -> (0.16, -0.16, 1.03)} PhaseDelay=UseScanAngle Phi=0deg Theta=theta_inc
  FloquetCima: Floquet Port Faces=Air_Domain.face(+z) NumModes=4 Modes{Mode1{CharImp=Zpi} Mode2{CharImp=Zpi} Mode3{CharImp=Zpi} Mode4{CharImp=Zpi}} PhaseDelay=UseScanAngle Phi=0deg Theta=theta_inc LatticeAVector{(-0.16, -0.16, 1.03) -> (0.16, -0.16, 1.03)} LatticeBVector{(-0.16, -0.16, 1.03) -> (-0.16, 0.16, 1.03)} ModesCalculator{Frequency=1GHz PhiStart=0deg PhiStop=0deg PhiStep=0deg ThetaStart=0deg ThetaStop=0deg ThetaStep=0deg} ModesList{Mode{ModeNumber=1 IndexM=0 IndexN=0 KC2=0 PropagationState=Undefined Attenuation=0 PolarizationState=TE AffectsRefinement} Mode{ModeNumber=2 IndexM=0 IndexN=0 KC2=0 PropagationState=Undefined Attenuation=0 PolarizationState=TM AffectsRefinement} Mode{ModeNumber=3 IndexM=-1 IndexN=0 KC2=385531421917553 PropagationState=Undefined Attenuation=1.7054704e+08 PolarizationState=TE AffectsRefinement} Mode{ModeNumber=4 IndexM=0 IndexN=-1 KC2=385531421917553 PropagationState=Undefined Attenuation=1.7054704e+08 PolarizationState=TE AffectsRefinement}}
  FloquetBaixo: Floquet Port Faces=Air_Domain.face(-z) NumModes=4 Modes{Mode1{CharImp=Zpi} Mode2{CharImp=Zpi} Mode3{CharImp=Zpi} Mode4{CharImp=Zpi}} PhaseDelay=UseScanAngle Phi=0deg Theta=theta_inc LatticeAVector{(-0.16, -0.16, -1) -> (0.16, -0.16, -1)} LatticeBVector{(-0.16, -0.16, -1) -> (-0.16, 0.16, -1)} ModesCalculator{Frequency=1GHz PhiStart=0deg PhiStop=0deg PhiStep=0deg ThetaStart=0deg ThetaStop=0deg ThetaStep=0deg} ModesList{Mode{ModeNumber=1 IndexM=0 IndexN=0 KC2=0 PropagationState=Undefined Attenuation=0 PolarizationState=TE AffectsRefinement} Mode{ModeNumber=2 IndexM=0 IndexN=0 KC2=0 PropagationState=Undefined Attenuation=0 PolarizationState=TM AffectsRefinement} Mode{ModeNumber=3 IndexM=-1 IndexN=0 KC2=385531421917553 PropagationState=Undefined Attenuation=1.7054704e+08 PolarizationState=TE AffectsRefinement} Mode{ModeNumber=4 IndexM=0 IndexN=-1 KC2=385531421917553 PropagationState=Undefined Attenuation=1.7054704e+08 PolarizationState=TE AffectsRefinement}}
setups:
  Setup1: HfssDriven Frequency=666.2THz MaxDeltaS=0.01 MaximumPasses=15 MinimumPasses=1 MinimumConvergedPasses=1 PercentRefinement=30 BasisOrder=1 PortAccuracy=2 DrivenSolverType="Direct Solver"
    sweep Varredura: 187.4THz to 666.2THz, 401 points; Type=Interpolating InterpTolerance=0.5 InterpMaxSolns=250 PassivityErrorTolerance=0.0001
source amplitudes:
  FloquetCima:1: 1W 0deg
  FloquetCima:2, FloquetCima:3, FloquetCima:4, FloquetBaixo:1..FloquetBaixo:4: 0W 0deg

design G0358_anelQ (HFSS, HFSS Modal Network, model units um)
variables:
  theta_inc = 0deg
geometry:
  Au_anelq [Au_JC] = box(corner=(-0.0665um, -0.0665um, 0um), size=(0.133um, 0.133um, 0.03um))
  Au_anelq_furo = box(corner=(-0.0375um, -0.0375um, 0um), size=(0.075um, 0.075um, 0.03um))
  Au_anelq.subtract(Au_anelq_furo)
  Air_Domain [vacuum] = box(corner=(-0.16um, -0.16um, -1um), size=(0.32um, 0.32um, 2.03um))
  Au_anelq_1 = Au_anelq.copy()
  Air_Domain.subtract(Au_anelq_1)
boundaries and excitations:
  LatticePair_X9M20Y: Lattice Pair Faces=Air_Domain.face(-x, +x) CoordSysVector{(-0.16, -0.16, -1) -> (-0.16, -0.16, 1.03)} PhaseDelay=UseScanAngle Phi=0deg Theta=theta_inc
  LatticePair_3C1CLE: Lattice Pair Faces=Air_Domain.face(-y, +y) CoordSysVector{(0.16, -0.16, -1) -> (0.16, -0.16, 1.03)} PhaseDelay=UseScanAngle Phi=0deg Theta=theta_inc
  FloquetCima: Floquet Port Faces=Air_Domain.face(+z) NumModes=4 Modes{Mode1{CharImp=Zpi} Mode2{CharImp=Zpi} Mode3{CharImp=Zpi} Mode4{CharImp=Zpi}} PhaseDelay=UseScanAngle Phi=0deg Theta=theta_inc LatticeAVector{(-0.16, -0.16, 1.03) -> (0.16, -0.16, 1.03)} LatticeBVector{(-0.16, -0.16, 1.03) -> (-0.16, 0.16, 1.03)} ModesCalculator{Frequency=1GHz PhiStart=0deg PhiStop=0deg PhiStep=0deg ThetaStart=0deg ThetaStop=0deg ThetaStep=0deg} ModesList{Mode{ModeNumber=1 IndexM=0 IndexN=0 KC2=0 PropagationState=Undefined Attenuation=0 PolarizationState=TE AffectsRefinement} Mode{ModeNumber=2 IndexM=0 IndexN=0 KC2=0 PropagationState=Undefined Attenuation=0 PolarizationState=TM AffectsRefinement} Mode{ModeNumber=3 IndexM=-1 IndexN=0 KC2=385531421917553 PropagationState=Undefined Attenuation=1.7054704e+08 PolarizationState=TE AffectsRefinement} Mode{ModeNumber=4 IndexM=0 IndexN=-1 KC2=385531421917553 PropagationState=Undefined Attenuation=1.7054704e+08 PolarizationState=TE AffectsRefinement}}
  FloquetBaixo: Floquet Port Faces=Air_Domain.face(-z) NumModes=4 Modes{Mode1{CharImp=Zpi} Mode2{CharImp=Zpi} Mode3{CharImp=Zpi} Mode4{CharImp=Zpi}} PhaseDelay=UseScanAngle Phi=0deg Theta=theta_inc LatticeAVector{(-0.16, -0.16, -1) -> (0.16, -0.16, -1)} LatticeBVector{(-0.16, -0.16, -1) -> (-0.16, 0.16, -1)} ModesCalculator{Frequency=1GHz PhiStart=0deg PhiStop=0deg PhiStep=0deg ThetaStart=0deg ThetaStop=0deg ThetaStep=0deg} ModesList{Mode{ModeNumber=1 IndexM=0 IndexN=0 KC2=0 PropagationState=Undefined Attenuation=0 PolarizationState=TE AffectsRefinement} Mode{ModeNumber=2 IndexM=0 IndexN=0 KC2=0 PropagationState=Undefined Attenuation=0 PolarizationState=TM AffectsRefinement} Mode{ModeNumber=3 IndexM=-1 IndexN=0 KC2=385531421917553 PropagationState=Undefined Attenuation=1.7054704e+08 PolarizationState=TE AffectsRefinement} Mode{ModeNumber=4 IndexM=0 IndexN=-1 KC2=385531421917553 PropagationState=Undefined Attenuation=1.7054704e+08 PolarizationState=TE AffectsRefinement}}
setups:
  Setup1: HfssDriven Frequency=666.2THz MaxDeltaS=0.01 MaximumPasses=15 MinimumPasses=1 MinimumConvergedPasses=1 PercentRefinement=30 BasisOrder=1 PortAccuracy=2 DrivenSolverType="Direct Solver"
    sweep Varredura: 187.4THz to 666.2THz, 401 points; Type=Interpolating InterpTolerance=0.5 InterpMaxSolns=250 PassivityErrorTolerance=0.0001
source amplitudes:
  FloquetCima:1: 1W 0deg
  FloquetCima:2, FloquetCima:3, FloquetCima:4, FloquetBaixo:1..FloquetBaixo:4: 0W 0deg

design G0479_anelQ_anelC (HFSS, HFSS Modal Network, model units um)
variables:
  theta_inc = 0deg
geometry:
  Au_anelq [Au_JC] = box(corner=(-0.0935um, -0.0935um, 0um), size=(0.187um, 0.187um, 0.03um))
  Au_anelq_furo = box(corner=(-0.0615um, -0.0615um, 0um), size=(0.123um, 0.123um, 0.03um))
  Au_anelq.subtract(Au_anelq_furo)
  Au_anelc = cylinder(axis=Z, base_centre=(0um, 0um, 0um), radius=0.042um, height=0.03um)
  Au_anelc_furo = cylinder(axis=Z, base_centre=(0um, 0um, 0um), radius=0.015um, height=0.03um)
  Au_anelc.subtract(Au_anelc_furo)
  Au_anelq.unite(Au_anelc)
  Air_Domain [vacuum] = box(corner=(-0.16um, -0.16um, -1um), size=(0.32um, 0.32um, 2.03um))
  Au_anelq_1 = Au_anelq.copy()
  Air_Domain.subtract(Au_anelq_1)
boundaries and excitations:
  LatticePair_QEK3I0: Lattice Pair Faces=Air_Domain.face(-x, +x) CoordSysVector{(-0.16, -0.16, -1) -> (-0.16, -0.16, 1.03)} PhaseDelay=UseScanAngle Phi=0deg Theta=theta_inc
  LatticePair_26UPEG: Lattice Pair Faces=Air_Domain.face(-y, +y) CoordSysVector{(0.16, -0.16, -1) -> (0.16, -0.16, 1.03)} PhaseDelay=UseScanAngle Phi=0deg Theta=theta_inc
  FloquetCima: Floquet Port Faces=Air_Domain.face(+z) NumModes=4 Modes{Mode1{CharImp=Zpi} Mode2{CharImp=Zpi} Mode3{CharImp=Zpi} Mode4{CharImp=Zpi}} PhaseDelay=UseScanAngle Phi=0deg Theta=theta_inc LatticeAVector{(-0.16, -0.16, 1.03) -> (0.16, -0.16, 1.03)} LatticeBVector{(-0.16, -0.16, 1.03) -> (-0.16, 0.16, 1.03)} ModesCalculator{Frequency=1GHz PhiStart=0deg PhiStop=0deg PhiStep=0deg ThetaStart=0deg ThetaStop=0deg ThetaStep=0deg} ModesList{Mode{ModeNumber=1 IndexM=0 IndexN=0 KC2=0 PropagationState=Undefined Attenuation=0 PolarizationState=TE AffectsRefinement} Mode{ModeNumber=2 IndexM=0 IndexN=0 KC2=0 PropagationState=Undefined Attenuation=0 PolarizationState=TM AffectsRefinement} Mode{ModeNumber=3 IndexM=-1 IndexN=0 KC2=385531421917553 PropagationState=Undefined Attenuation=1.7054704e+08 PolarizationState=TE AffectsRefinement} Mode{ModeNumber=4 IndexM=0 IndexN=-1 KC2=385531421917553 PropagationState=Undefined Attenuation=1.7054704e+08 PolarizationState=TE AffectsRefinement}}
  FloquetBaixo: Floquet Port Faces=Air_Domain.face(-z) NumModes=4 Modes{Mode1{CharImp=Zpi} Mode2{CharImp=Zpi} Mode3{CharImp=Zpi} Mode4{CharImp=Zpi}} PhaseDelay=UseScanAngle Phi=0deg Theta=theta_inc LatticeAVector{(-0.16, -0.16, -1) -> (0.16, -0.16, -1)} LatticeBVector{(-0.16, -0.16, -1) -> (-0.16, 0.16, -1)} ModesCalculator{Frequency=1GHz PhiStart=0deg PhiStop=0deg PhiStep=0deg ThetaStart=0deg ThetaStop=0deg ThetaStep=0deg} ModesList{Mode{ModeNumber=1 IndexM=0 IndexN=0 KC2=0 PropagationState=Undefined Attenuation=0 PolarizationState=TE AffectsRefinement} Mode{ModeNumber=2 IndexM=0 IndexN=0 KC2=0 PropagationState=Undefined Attenuation=0 PolarizationState=TM AffectsRefinement} Mode{ModeNumber=3 IndexM=-1 IndexN=0 KC2=385531421917553 PropagationState=Undefined Attenuation=1.7054704e+08 PolarizationState=TE AffectsRefinement} Mode{ModeNumber=4 IndexM=0 IndexN=-1 KC2=385531421917553 PropagationState=Undefined Attenuation=1.7054704e+08 PolarizationState=TE AffectsRefinement}}
setups:
  Setup1: HfssDriven Frequency=666.2THz MaxDeltaS=0.01 MaximumPasses=15 MinimumPasses=1 MinimumConvergedPasses=1 PercentRefinement=30 BasisOrder=1 PortAccuracy=2 DrivenSolverType="Direct Solver"
    sweep Varredura: 187.4THz to 666.2THz, 401 points; Type=Interpolating InterpTolerance=0.5 InterpMaxSolns=250 PassivityErrorTolerance=0.0001
source amplitudes:
  FloquetCima:1: 1W 0deg
  FloquetCima:2, FloquetCima:3, FloquetCima:4, FloquetBaixo:1..FloquetBaixo:4: 0W 0deg

design G0466_anelQ_anelC (HFSS, HFSS Modal Network, model units um)
variables:
  theta_inc = 0deg
geometry:
  Au_anelq [Au_JC] = box(corner=(-0.086um, -0.086um, 0um), size=(0.172um, 0.172um, 0.03um))
  Au_anelq_furo = box(corner=(-0.045um, -0.045um, 0um), size=(0.09um, 0.09um, 0.03um))
  Au_anelq.subtract(Au_anelq_furo)
  Au_anelc = cylinder(axis=Z, base_centre=(0um, 0um, 0um), radius=0.035um, height=0.03um)
  Au_anelc_furo = cylinder(axis=Z, base_centre=(0um, 0um, 0um), radius=0.017um, height=0.03um)
  Au_anelc.subtract(Au_anelc_furo)
  Au_anelq.unite(Au_anelc)
  Air_Domain [vacuum] = box(corner=(-0.16um, -0.16um, -1um), size=(0.32um, 0.32um, 2.03um))
  Au_anelq_1 = Au_anelq.copy()
  Air_Domain.subtract(Au_anelq_1)
boundaries and excitations:
  LatticePair_6VHJJS: Lattice Pair Faces=Air_Domain.face(-x, +x) CoordSysVector{(-0.16, -0.16, -1) -> (-0.16, -0.16, 1.03)} PhaseDelay=UseScanAngle Phi=0deg Theta=theta_inc
  LatticePair_Q66SNX: Lattice Pair Faces=Air_Domain.face(-y, +y) CoordSysVector{(0.16, -0.16, -1) -> (0.16, -0.16, 1.03)} PhaseDelay=UseScanAngle Phi=0deg Theta=theta_inc
  FloquetCima: Floquet Port Faces=Air_Domain.face(+z) NumModes=4 Modes{Mode1{CharImp=Zpi} Mode2{CharImp=Zpi} Mode3{CharImp=Zpi} Mode4{CharImp=Zpi}} PhaseDelay=UseScanAngle Phi=0deg Theta=theta_inc LatticeAVector{(-0.16, -0.16, 1.03) -> (0.16, -0.16, 1.03)} LatticeBVector{(-0.16, -0.16, 1.03) -> (-0.16, 0.16, 1.03)} ModesCalculator{Frequency=1GHz PhiStart=0deg PhiStop=0deg PhiStep=0deg ThetaStart=0deg ThetaStop=0deg ThetaStep=0deg} ModesList{Mode{ModeNumber=1 IndexM=0 IndexN=0 KC2=0 PropagationState=Undefined Attenuation=0 PolarizationState=TE AffectsRefinement} Mode{ModeNumber=2 IndexM=0 IndexN=0 KC2=0 PropagationState=Undefined Attenuation=0 PolarizationState=TM AffectsRefinement} Mode{ModeNumber=3 IndexM=-1 IndexN=0 KC2=385531421917553 PropagationState=Undefined Attenuation=1.7054704e+08 PolarizationState=TE AffectsRefinement} Mode{ModeNumber=4 IndexM=0 IndexN=-1 KC2=385531421917553 PropagationState=Undefined Attenuation=1.7054704e+08 PolarizationState=TE AffectsRefinement}}
  FloquetBaixo: Floquet Port Faces=Air_Domain.face(-z) NumModes=4 Modes{Mode1{CharImp=Zpi} Mode2{CharImp=Zpi} Mode3{CharImp=Zpi} Mode4{CharImp=Zpi}} PhaseDelay=UseScanAngle Phi=0deg Theta=theta_inc LatticeAVector{(-0.16, -0.16, -1) -> (0.16, -0.16, -1)} LatticeBVector{(-0.16, -0.16, -1) -> (-0.16, 0.16, -1)} ModesCalculator{Frequency=1GHz PhiStart=0deg PhiStop=0deg PhiStep=0deg ThetaStart=0deg ThetaStop=0deg ThetaStep=0deg} ModesList{Mode{ModeNumber=1 IndexM=0 IndexN=0 KC2=0 PropagationState=Undefined Attenuation=0 PolarizationState=TE AffectsRefinement} Mode{ModeNumber=2 IndexM=0 IndexN=0 KC2=0 PropagationState=Undefined Attenuation=0 PolarizationState=TM AffectsRefinement} Mode{ModeNumber=3 IndexM=-1 IndexN=0 KC2=385531421917553 PropagationState=Undefined Attenuation=1.7054704e+08 PolarizationState=TE AffectsRefinement} Mode{ModeNumber=4 IndexM=0 IndexN=-1 KC2=385531421917553 PropagationState=Undefined Attenuation=1.7054704e+08 PolarizationState=TE AffectsRefinement}}
setups:
  Setup1: HfssDriven Frequency=666.2THz MaxDeltaS=0.01 MaximumPasses=15 MinimumPasses=1 MinimumConvergedPasses=1 PercentRefinement=30 BasisOrder=1 PortAccuracy=2 DrivenSolverType="Direct Solver"
    sweep Varredura: 187.4THz to 666.2THz, 401 points; Type=Interpolating InterpTolerance=0.5 InterpMaxSolns=250 PassivityErrorTolerance=0.0001
source amplitudes:
  FloquetCima:1: 1W 0deg
  FloquetCima:2, FloquetCima:3, FloquetCima:4, FloquetBaixo:1..FloquetBaixo:4: 0W 0deg

design G0600_anelQ_anelC (HFSS, HFSS Modal Network, model units um)
variables:
  theta_inc = 0deg
geometry:
  Au_anelq [Au_JC] = box(corner=(-0.116um, -0.116um, 0um), size=(0.232um, 0.232um, 0.03um))
  Au_anelq_furo = box(corner=(-0.09um, -0.09um, 0um), size=(0.18um, 0.18um, 0.03um))
  Au_anelq.subtract(Au_anelq_furo)
  Au_anelc = cylinder(axis=Z, base_centre=(0um, 0um, 0um), radius=0.053um, height=0.03um)
  Au_anelc_furo = cylinder(axis=Z, base_centre=(0um, 0um, 0um), radius=0.019um, height=0.03um)
  Au_anelc.subtract(Au_anelc_furo)
  Au_anelq.unite(Au_anelc)
  Air_Domain [vacuum] = box(corner=(-0.16um, -0.16um, -1um), size=(0.32um, 0.32um, 2.03um))
  Au_anelq_1 = Au_anelq.copy()
  Air_Domain.subtract(Au_anelq_1)
boundaries and excitations:
  LatticePair_K825WP: Lattice Pair Faces=Air_Domain.face(-x, +x) CoordSysVector{(-0.16, -0.16, -1) -> (-0.16, -0.16, 1.03)} PhaseDelay=UseScanAngle Phi=0deg Theta=theta_inc
  LatticePair_F6XWH3: Lattice Pair Faces=Air_Domain.face(-y, +y) CoordSysVector{(0.16, -0.16, -1) -> (0.16, -0.16, 1.03)} PhaseDelay=UseScanAngle Phi=0deg Theta=theta_inc
  FloquetCima: Floquet Port Faces=Air_Domain.face(+z) NumModes=4 Modes{Mode1{CharImp=Zpi} Mode2{CharImp=Zpi} Mode3{CharImp=Zpi} Mode4{CharImp=Zpi}} PhaseDelay=UseScanAngle Phi=0deg Theta=theta_inc LatticeAVector{(-0.16, -0.16, 1.03) -> (0.16, -0.16, 1.03)} LatticeBVector{(-0.16, -0.16, 1.03) -> (-0.16, 0.16, 1.03)} ModesCalculator{Frequency=1GHz PhiStart=0deg PhiStop=0deg PhiStep=0deg ThetaStart=0deg ThetaStop=0deg ThetaStep=0deg} ModesList{Mode{ModeNumber=1 IndexM=0 IndexN=0 KC2=0 PropagationState=Undefined Attenuation=0 PolarizationState=TE AffectsRefinement} Mode{ModeNumber=2 IndexM=0 IndexN=0 KC2=0 PropagationState=Undefined Attenuation=0 PolarizationState=TM AffectsRefinement} Mode{ModeNumber=3 IndexM=-1 IndexN=0 KC2=385531421917553 PropagationState=Undefined Attenuation=1.7054704e+08 PolarizationState=TE AffectsRefinement} Mode{ModeNumber=4 IndexM=0 IndexN=-1 KC2=385531421917553 PropagationState=Undefined Attenuation=1.7054704e+08 PolarizationState=TE AffectsRefinement}}
  FloquetBaixo: Floquet Port Faces=Air_Domain.face(-z) NumModes=4 Modes{Mode1{CharImp=Zpi} Mode2{CharImp=Zpi} Mode3{CharImp=Zpi} Mode4{CharImp=Zpi}} PhaseDelay=UseScanAngle Phi=0deg Theta=theta_inc LatticeAVector{(-0.16, -0.16, -1) -> (0.16, -0.16, -1)} LatticeBVector{(-0.16, -0.16, -1) -> (-0.16, 0.16, -1)} ModesCalculator{Frequency=1GHz PhiStart=0deg PhiStop=0deg PhiStep=0deg ThetaStart=0deg ThetaStop=0deg ThetaStep=0deg} ModesList{Mode{ModeNumber=1 IndexM=0 IndexN=0 KC2=0 PropagationState=Undefined Attenuation=0 PolarizationState=TE AffectsRefinement} Mode{ModeNumber=2 IndexM=0 IndexN=0 KC2=0 PropagationState=Undefined Attenuation=0 PolarizationState=TM AffectsRefinement} Mode{ModeNumber=3 IndexM=-1 IndexN=0 KC2=385531421917553 PropagationState=Undefined Attenuation=1.7054704e+08 PolarizationState=TE AffectsRefinement} Mode{ModeNumber=4 IndexM=0 IndexN=-1 KC2=385531421917553 PropagationState=Undefined Attenuation=1.7054704e+08 PolarizationState=TE AffectsRefinement}}
setups:
  Setup1: HfssDriven Frequency=666.2THz MaxDeltaS=0.01 MaximumPasses=15 MinimumPasses=1 MinimumConvergedPasses=1 PercentRefinement=30 BasisOrder=1 PortAccuracy=2 DrivenSolverType="Direct Solver"
    sweep Varredura: 187.4THz to 666.2THz, 401 points; Type=Interpolating InterpTolerance=0.5 InterpMaxSolns=250 PassivityErrorTolerance=0.0001
source amplitudes:
  FloquetCima:1: 1W 0deg
  FloquetCima:2, FloquetCima:3, FloquetCima:4, FloquetBaixo:1..FloquetBaixo:4: 0W 0deg

design G0492_anelQ_anelC (HFSS, HFSS Modal Network, model units um)
variables:
  theta_inc = 0deg
geometry:
  Au_anelq [Au_JC] = box(corner=(-0.115um, -0.115um, 0um), size=(0.23um, 0.23um, 0.03um))
  Au_anelq_furo = box(corner=(-0.076um, -0.076um, 0um), size=(0.152um, 0.152um, 0.03um))
  Au_anelq.subtract(Au_anelq_furo)
  Au_anelc = cylinder(axis=Z, base_centre=(0um, 0um, 0um), radius=0.05um, height=0.03um)
  Au_anelc_furo = cylinder(axis=Z, base_centre=(0um, 0um, 0um), radius=0.023um, height=0.03um)
  Au_anelc.subtract(Au_anelc_furo)
  Au_anelq.unite(Au_anelc)
  Air_Domain [vacuum] = box(corner=(-0.16um, -0.16um, -1um), size=(0.32um, 0.32um, 2.03um))
  Au_anelq_1 = Au_anelq.copy()
  Air_Domain.subtract(Au_anelq_1)
boundaries and excitations:
  LatticePair_MXP3GT: Lattice Pair Faces=Air_Domain.face(-x, +x) CoordSysVector{(-0.16, -0.16, -1) -> (-0.16, -0.16, 1.03)} PhaseDelay=UseScanAngle Phi=0deg Theta=theta_inc
  LatticePair_55N1EZ: Lattice Pair Faces=Air_Domain.face(-y, +y) CoordSysVector{(0.16, -0.16, -1) -> (0.16, -0.16, 1.03)} PhaseDelay=UseScanAngle Phi=0deg Theta=theta_inc
  FloquetCima: Floquet Port Faces=Air_Domain.face(+z) NumModes=4 Modes{Mode1{CharImp=Zpi} Mode2{CharImp=Zpi} Mode3{CharImp=Zpi} Mode4{CharImp=Zpi}} PhaseDelay=UseScanAngle Phi=0deg Theta=theta_inc LatticeAVector{(-0.16, -0.16, 1.03) -> (0.16, -0.16, 1.03)} LatticeBVector{(-0.16, -0.16, 1.03) -> (-0.16, 0.16, 1.03)} ModesCalculator{Frequency=1GHz PhiStart=0deg PhiStop=0deg PhiStep=0deg ThetaStart=0deg ThetaStop=0deg ThetaStep=0deg} ModesList{Mode{ModeNumber=1 IndexM=0 IndexN=0 KC2=0 PropagationState=Undefined Attenuation=0 PolarizationState=TE AffectsRefinement} Mode{ModeNumber=2 IndexM=0 IndexN=0 KC2=0 PropagationState=Undefined Attenuation=0 PolarizationState=TM AffectsRefinement} Mode{ModeNumber=3 IndexM=-1 IndexN=0 KC2=385531421917553 PropagationState=Undefined Attenuation=1.7054704e+08 PolarizationState=TE AffectsRefinement} Mode{ModeNumber=4 IndexM=0 IndexN=-1 KC2=385531421917553 PropagationState=Undefined Attenuation=1.7054704e+08 PolarizationState=TE AffectsRefinement}}
  FloquetBaixo: Floquet Port Faces=Air_Domain.face(-z) NumModes=4 Modes{Mode1{CharImp=Zpi} Mode2{CharImp=Zpi} Mode3{CharImp=Zpi} Mode4{CharImp=Zpi}} PhaseDelay=UseScanAngle Phi=0deg Theta=theta_inc LatticeAVector{(-0.16, -0.16, -1) -> (0.16, -0.16, -1)} LatticeBVector{(-0.16, -0.16, -1) -> (-0.16, 0.16, -1)} ModesCalculator{Frequency=1GHz PhiStart=0deg PhiStop=0deg PhiStep=0deg ThetaStart=0deg ThetaStop=0deg ThetaStep=0deg} ModesList{Mode{ModeNumber=1 IndexM=0 IndexN=0 KC2=0 PropagationState=Undefined Attenuation=0 PolarizationState=TE AffectsRefinement} Mode{ModeNumber=2 IndexM=0 IndexN=0 KC2=0 PropagationState=Undefined Attenuation=0 PolarizationState=TM AffectsRefinement} Mode{ModeNumber=3 IndexM=-1 IndexN=0 KC2=385531421917553 PropagationState=Undefined Attenuation=1.7054704e+08 PolarizationState=TE AffectsRefinement} Mode{ModeNumber=4 IndexM=0 IndexN=-1 KC2=385531421917553 PropagationState=Undefined Attenuation=1.7054704e+08 PolarizationState=TE AffectsRefinement}}
setups:
  Setup1: HfssDriven Frequency=666.2THz MaxDeltaS=0.01 MaximumPasses=15 MinimumPasses=1 MinimumConvergedPasses=1 PercentRefinement=30 BasisOrder=1 PortAccuracy=2 DrivenSolverType="Direct Solver"
    sweep Varredura: 187.4THz to 666.2THz, 401 points; Type=Interpolating InterpTolerance=0.5 InterpMaxSolns=250 PassivityErrorTolerance=0.0001
source amplitudes:
  FloquetCima:1: 1W 0deg
  FloquetCima:2, FloquetCima:3, FloquetCima:4, FloquetBaixo:1..FloquetBaixo:4: 0W 0deg

design G0417_anelQ_anelC (HFSS, HFSS Modal Network, model units um)
variables:
  theta_inc = 0deg
geometry:
  Au_anelq [Au_JC] = box(corner=(-0.1165um, -0.1165um, 0um), size=(0.233um, 0.233um, 0.03um))
  Au_anelq_furo = box(corner=(-0.0715um, -0.0715um, 0um), size=(0.143um, 0.143um, 0.03um))
  Au_anelq.subtract(Au_anelq_furo)
  Au_anelc = cylinder(axis=Z, base_centre=(0um, 0um, 0um), radius=0.043um, height=0.03um)
  Au_anelc_furo = cylinder(axis=Z, base_centre=(0um, 0um, 0um), radius=0.023um, height=0.03um)
  Au_anelc.subtract(Au_anelc_furo)
  Au_anelq.unite(Au_anelc)
  Air_Domain [vacuum] = box(corner=(-0.16um, -0.16um, -1um), size=(0.32um, 0.32um, 2.03um))
  Au_anelq_1 = Au_anelq.copy()
  Air_Domain.subtract(Au_anelq_1)
boundaries and excitations:
  LatticePair_O4QZUN: Lattice Pair Faces=Air_Domain.face(-x, +x) CoordSysVector{(-0.16, -0.16, -1) -> (-0.16, -0.16, 1.03)} PhaseDelay=UseScanAngle Phi=0deg Theta=theta_inc
  LatticePair_TBMROD: Lattice Pair Faces=Air_Domain.face(-y, +y) CoordSysVector{(0.16, -0.16, -1) -> (0.16, -0.16, 1.03)} PhaseDelay=UseScanAngle Phi=0deg Theta=theta_inc
  FloquetCima: Floquet Port Faces=Air_Domain.face(+z) NumModes=4 Modes{Mode1{CharImp=Zpi} Mode2{CharImp=Zpi} Mode3{CharImp=Zpi} Mode4{CharImp=Zpi}} PhaseDelay=UseScanAngle Phi=0deg Theta=theta_inc LatticeAVector{(-0.16, -0.16, 1.03) -> (0.16, -0.16, 1.03)} LatticeBVector{(-0.16, -0.16, 1.03) -> (-0.16, 0.16, 1.03)} ModesCalculator{Frequency=1GHz PhiStart=0deg PhiStop=0deg PhiStep=0deg ThetaStart=0deg ThetaStop=0deg ThetaStep=0deg} ModesList{Mode{ModeNumber=1 IndexM=0 IndexN=0 KC2=0 PropagationState=Undefined Attenuation=0 PolarizationState=TE AffectsRefinement} Mode{ModeNumber=2 IndexM=0 IndexN=0 KC2=0 PropagationState=Undefined Attenuation=0 PolarizationState=TM AffectsRefinement} Mode{ModeNumber=3 IndexM=-1 IndexN=0 KC2=385531421917553 PropagationState=Undefined Attenuation=1.7054704e+08 PolarizationState=TE AffectsRefinement} Mode{ModeNumber=4 IndexM=0 IndexN=-1 KC2=385531421917553 PropagationState=Undefined Attenuation=1.7054704e+08 PolarizationState=TE AffectsRefinement}}
  FloquetBaixo: Floquet Port Faces=Air_Domain.face(-z) NumModes=4 Modes{Mode1{CharImp=Zpi} Mode2{CharImp=Zpi} Mode3{CharImp=Zpi} Mode4{CharImp=Zpi}} PhaseDelay=UseScanAngle Phi=0deg Theta=theta_inc LatticeAVector{(-0.16, -0.16, -1) -> (0.16, -0.16, -1)} LatticeBVector{(-0.16, -0.16, -1) -> (-0.16, 0.16, -1)} ModesCalculator{Frequency=1GHz PhiStart=0deg PhiStop=0deg PhiStep=0deg ThetaStart=0deg ThetaStop=0deg ThetaStep=0deg} ModesList{Mode{ModeNumber=1 IndexM=0 IndexN=0 KC2=0 PropagationState=Undefined Attenuation=0 PolarizationState=TE AffectsRefinement} Mode{ModeNumber=2 IndexM=0 IndexN=0 KC2=0 PropagationState=Undefined Attenuation=0 PolarizationState=TM AffectsRefinement} Mode{ModeNumber=3 IndexM=-1 IndexN=0 KC2=385531421917553 PropagationState=Undefined Attenuation=1.7054704e+08 PolarizationState=TE AffectsRefinement} Mode{ModeNumber=4 IndexM=0 IndexN=-1 KC2=385531421917553 PropagationState=Undefined Attenuation=1.7054704e+08 PolarizationState=TE AffectsRefinement}}
setups:
  Setup1: HfssDriven Frequency=666.2THz MaxDeltaS=0.01 MaximumPasses=15 MinimumPasses=1 MinimumConvergedPasses=1 PercentRefinement=30 BasisOrder=1 PortAccuracy=2 DrivenSolverType="Direct Solver"
    sweep Varredura: 187.4THz to 666.2THz, 401 points; Type=Interpolating InterpTolerance=0.5 InterpMaxSolns=250 PassivityErrorTolerance=0.0001
source amplitudes:
  FloquetCima:1: 1W 0deg
  FloquetCima:2, FloquetCima:3, FloquetCima:4, FloquetBaixo:1..FloquetBaixo:4: 0W 0deg

design G0577_anelQ_anelC (HFSS, HFSS Modal Network, model units um)
variables:
  theta_inc = 0deg
geometry:
  Au_anelq [Au_JC] = box(corner=(-0.096um, -0.096um, 0um), size=(0.192um, 0.192um, 0.03um))
  Au_anelq_furo = box(corner=(-0.067um, -0.067um, 0um), size=(0.134um, 0.134um, 0.03um))
  Au_anelq.subtract(Au_anelq_furo)
  Au_anelc = cylinder(axis=Z, base_centre=(0um, 0um, 0um), radius=0.056um, height=0.03um)
  Au_anelc_furo = cylinder(axis=Z, base_centre=(0um, 0um, 0um), radius=0.029um, height=0.03um)
  Au_anelc.subtract(Au_anelc_furo)
  Au_anelq.unite(Au_anelc)
  Air_Domain [vacuum] = box(corner=(-0.16um, -0.16um, -1um), size=(0.32um, 0.32um, 2.03um))
  Au_anelq_1 = Au_anelq.copy()
  Air_Domain.subtract(Au_anelq_1)
boundaries and excitations:
  LatticePair_IO34M7: Lattice Pair Faces=Air_Domain.face(-x, +x) CoordSysVector{(-0.16, -0.16, -1) -> (-0.16, -0.16, 1.03)} PhaseDelay=UseScanAngle Phi=0deg Theta=theta_inc
  LatticePair_XBLG6H: Lattice Pair Faces=Air_Domain.face(-y, +y) CoordSysVector{(0.16, -0.16, -1) -> (0.16, -0.16, 1.03)} PhaseDelay=UseScanAngle Phi=0deg Theta=theta_inc
  FloquetCima: Floquet Port Faces=Air_Domain.face(+z) NumModes=4 Modes{Mode1{CharImp=Zpi} Mode2{CharImp=Zpi} Mode3{CharImp=Zpi} Mode4{CharImp=Zpi}} PhaseDelay=UseScanAngle Phi=0deg Theta=theta_inc LatticeAVector{(-0.16, -0.16, 1.03) -> (0.16, -0.16, 1.03)} LatticeBVector{(-0.16, -0.16, 1.03) -> (-0.16, 0.16, 1.03)} ModesCalculator{Frequency=1GHz PhiStart=0deg PhiStop=0deg PhiStep=0deg ThetaStart=0deg ThetaStop=0deg ThetaStep=0deg} ModesList{Mode{ModeNumber=1 IndexM=0 IndexN=0 KC2=0 PropagationState=Undefined Attenuation=0 PolarizationState=TE AffectsRefinement} Mode{ModeNumber=2 IndexM=0 IndexN=0 KC2=0 PropagationState=Undefined Attenuation=0 PolarizationState=TM AffectsRefinement} Mode{ModeNumber=3 IndexM=-1 IndexN=0 KC2=385531421917553 PropagationState=Undefined Attenuation=1.7054704e+08 PolarizationState=TE AffectsRefinement} Mode{ModeNumber=4 IndexM=0 IndexN=-1 KC2=385531421917553 PropagationState=Undefined Attenuation=1.7054704e+08 PolarizationState=TE AffectsRefinement}}
  FloquetBaixo: Floquet Port Faces=Air_Domain.face(-z) NumModes=4 Modes{Mode1{CharImp=Zpi} Mode2{CharImp=Zpi} Mode3{CharImp=Zpi} Mode4{CharImp=Zpi}} PhaseDelay=UseScanAngle Phi=0deg Theta=theta_inc LatticeAVector{(-0.16, -0.16, -1) -> (0.16, -0.16, -1)} LatticeBVector{(-0.16, -0.16, -1) -> (-0.16, 0.16, -1)} ModesCalculator{Frequency=1GHz PhiStart=0deg PhiStop=0deg PhiStep=0deg ThetaStart=0deg ThetaStop=0deg ThetaStep=0deg} ModesList{Mode{ModeNumber=1 IndexM=0 IndexN=0 KC2=0 PropagationState=Undefined Attenuation=0 PolarizationState=TE AffectsRefinement} Mode{ModeNumber=2 IndexM=0 IndexN=0 KC2=0 PropagationState=Undefined Attenuation=0 PolarizationState=TM AffectsRefinement} Mode{ModeNumber=3 IndexM=-1 IndexN=0 KC2=385531421917553 PropagationState=Undefined Attenuation=1.7054704e+08 PolarizationState=TE AffectsRefinement} Mode{ModeNumber=4 IndexM=0 IndexN=-1 KC2=385531421917553 PropagationState=Undefined Attenuation=1.7054704e+08 PolarizationState=TE AffectsRefinement}}
setups:
  Setup1: HfssDriven Frequency=666.2THz MaxDeltaS=0.01 MaximumPasses=15 MinimumPasses=1 MinimumConvergedPasses=1 PercentRefinement=30 BasisOrder=1 PortAccuracy=2 DrivenSolverType="Direct Solver"
    sweep Varredura: 187.4THz to 666.2THz, 401 points; Type=Interpolating InterpTolerance=0.5 InterpMaxSolns=250 PassivityErrorTolerance=0.0001
source amplitudes:
  FloquetCima:1: 1W 0deg
  FloquetCima:2, FloquetCima:3, FloquetCima:4, FloquetBaixo:1..FloquetBaixo:4: 0W 0deg

design G0515_anelQ_anelC (HFSS, HFSS Modal Network, model units um)
variables:
  theta_inc = 0deg
geometry:
  Au_anelq [Au_JC] = box(corner=(-0.1115um, -0.1115um, 0um), size=(0.223um, 0.223um, 0.03um))
  Au_anelq_furo = box(corner=(-0.0835um, -0.0835um, 0um), size=(0.167um, 0.167um, 0.03um))
  Au_anelq.subtract(Au_anelq_furo)
  Au_anelc = cylinder(axis=Z, base_centre=(0um, 0um, 0um), radius=0.048um, height=0.03um)
  Au_anelc_furo = cylinder(axis=Z, base_centre=(0um, 0um, 0um), radius=0.028um, height=0.03um)
  Au_anelc.subtract(Au_anelc_furo)
  Au_anelq.unite(Au_anelc)
  Air_Domain [vacuum] = box(corner=(-0.16um, -0.16um, -1um), size=(0.32um, 0.32um, 2.03um))
  Au_anelq_1 = Au_anelq.copy()
  Air_Domain.subtract(Au_anelq_1)
boundaries and excitations:
  LatticePair_IF6Y3O: Lattice Pair Faces=Air_Domain.face(-x, +x) CoordSysVector{(-0.16, -0.16, -1) -> (-0.16, -0.16, 1.03)} PhaseDelay=UseScanAngle Phi=0deg Theta=theta_inc
  LatticePair_5VQGZ6: Lattice Pair Faces=Air_Domain.face(-y, +y) CoordSysVector{(0.16, -0.16, -1) -> (0.16, -0.16, 1.03)} PhaseDelay=UseScanAngle Phi=0deg Theta=theta_inc
  FloquetCima: Floquet Port Faces=Air_Domain.face(+z) NumModes=4 Modes{Mode1{CharImp=Zpi} Mode2{CharImp=Zpi} Mode3{CharImp=Zpi} Mode4{CharImp=Zpi}} PhaseDelay=UseScanAngle Phi=0deg Theta=theta_inc LatticeAVector{(-0.16, -0.16, 1.03) -> (0.16, -0.16, 1.03)} LatticeBVector{(-0.16, -0.16, 1.03) -> (-0.16, 0.16, 1.03)} ModesCalculator{Frequency=1GHz PhiStart=0deg PhiStop=0deg PhiStep=0deg ThetaStart=0deg ThetaStop=0deg ThetaStep=0deg} ModesList{Mode{ModeNumber=1 IndexM=0 IndexN=0 KC2=0 PropagationState=Undefined Attenuation=0 PolarizationState=TE AffectsRefinement} Mode{ModeNumber=2 IndexM=0 IndexN=0 KC2=0 PropagationState=Undefined Attenuation=0 PolarizationState=TM AffectsRefinement} Mode{ModeNumber=3 IndexM=-1 IndexN=0 KC2=385531421917553 PropagationState=Undefined Attenuation=1.7054704e+08 PolarizationState=TE AffectsRefinement} Mode{ModeNumber=4 IndexM=0 IndexN=-1 KC2=385531421917553 PropagationState=Undefined Attenuation=1.7054704e+08 PolarizationState=TE AffectsRefinement}}
  FloquetBaixo: Floquet Port Faces=Air_Domain.face(-z) NumModes=4 Modes{Mode1{CharImp=Zpi} Mode2{CharImp=Zpi} Mode3{CharImp=Zpi} Mode4{CharImp=Zpi}} PhaseDelay=UseScanAngle Phi=0deg Theta=theta_inc LatticeAVector{(-0.16, -0.16, -1) -> (0.16, -0.16, -1)} LatticeBVector{(-0.16, -0.16, -1) -> (-0.16, 0.16, -1)} ModesCalculator{Frequency=1GHz PhiStart=0deg PhiStop=0deg PhiStep=0deg ThetaStart=0deg ThetaStop=0deg ThetaStep=0deg} ModesList{Mode{ModeNumber=1 IndexM=0 IndexN=0 KC2=0 PropagationState=Undefined Attenuation=0 PolarizationState=TE AffectsRefinement} Mode{ModeNumber=2 IndexM=0 IndexN=0 KC2=0 PropagationState=Undefined Attenuation=0 PolarizationState=TM AffectsRefinement} Mode{ModeNumber=3 IndexM=-1 IndexN=0 KC2=385531421917553 PropagationState=Undefined Attenuation=1.7054704e+08 PolarizationState=TE AffectsRefinement} Mode{ModeNumber=4 IndexM=0 IndexN=-1 KC2=385531421917553 PropagationState=Undefined Attenuation=1.7054704e+08 PolarizationState=TE AffectsRefinement}}
setups:
  Setup1: HfssDriven Frequency=666.2THz MaxDeltaS=0.01 MaximumPasses=15 MinimumPasses=1 MinimumConvergedPasses=1 PercentRefinement=30 BasisOrder=1 PortAccuracy=2 DrivenSolverType="Direct Solver"
    sweep Varredura: 187.4THz to 666.2THz, 401 points; Type=Interpolating InterpTolerance=0.5 InterpMaxSolns=250 PassivityErrorTolerance=0.0001
source amplitudes:
  FloquetCima:1: 1W 0deg
  FloquetCima:2, FloquetCima:3, FloquetCima:4, FloquetBaixo:1..FloquetBaixo:4: 0W 0deg

design G0410_anelQ_anelC (HFSS, HFSS Modal Network, model units um)
variables:
  theta_inc = 0deg
geometry:
  Au_anelq [Au_JC] = box(corner=(-0.097um, -0.097um, 0um), size=(0.194um, 0.194um, 0.03um))
  Au_anelq_furo = box(corner=(-0.061um, -0.061um, 0um), size=(0.122um, 0.122um, 0.03um))
  Au_anelq.subtract(Au_anelq_furo)
  Au_anelc = cylinder(axis=Z, base_centre=(0um, 0um, 0um), radius=0.048um, height=0.03um)
  Au_anelc_furo = cylinder(axis=Z, base_centre=(0um, 0um, 0um), radius=0.03um, height=0.03um)
  Au_anelc.subtract(Au_anelc_furo)
  Au_anelq.unite(Au_anelc)
  Air_Domain [vacuum] = box(corner=(-0.16um, -0.16um, -1um), size=(0.32um, 0.32um, 2.03um))
  Au_anelq_1 = Au_anelq.copy()
  Air_Domain.subtract(Au_anelq_1)
boundaries and excitations:
  LatticePair_EF419O: Lattice Pair Faces=Air_Domain.face(-x, +x) CoordSysVector{(-0.16, -0.16, -1) -> (-0.16, -0.16, 1.03)} PhaseDelay=UseScanAngle Phi=0deg Theta=theta_inc
  LatticePair_5EHUKG: Lattice Pair Faces=Air_Domain.face(-y, +y) CoordSysVector{(0.16, -0.16, -1) -> (0.16, -0.16, 1.03)} PhaseDelay=UseScanAngle Phi=0deg Theta=theta_inc
  FloquetCima: Floquet Port Faces=Air_Domain.face(+z) NumModes=4 Modes{Mode1{CharImp=Zpi} Mode2{CharImp=Zpi} Mode3{CharImp=Zpi} Mode4{CharImp=Zpi}} PhaseDelay=UseScanAngle Phi=0deg Theta=theta_inc LatticeAVector{(-0.16, -0.16, 1.03) -> (0.16, -0.16, 1.03)} LatticeBVector{(-0.16, -0.16, 1.03) -> (-0.16, 0.16, 1.03)} ModesCalculator{Frequency=1GHz PhiStart=0deg PhiStop=0deg PhiStep=0deg ThetaStart=0deg ThetaStop=0deg ThetaStep=0deg} ModesList{Mode{ModeNumber=1 IndexM=0 IndexN=0 KC2=0 PropagationState=Undefined Attenuation=0 PolarizationState=TE AffectsRefinement} Mode{ModeNumber=2 IndexM=0 IndexN=0 KC2=0 PropagationState=Undefined Attenuation=0 PolarizationState=TM AffectsRefinement} Mode{ModeNumber=3 IndexM=-1 IndexN=0 KC2=385531421917553 PropagationState=Undefined Attenuation=1.7054704e+08 PolarizationState=TE AffectsRefinement} Mode{ModeNumber=4 IndexM=0 IndexN=-1 KC2=385531421917553 PropagationState=Undefined Attenuation=1.7054704e+08 PolarizationState=TE AffectsRefinement}}
  FloquetBaixo: Floquet Port Faces=Air_Domain.face(-z) NumModes=4 Modes{Mode1{CharImp=Zpi} Mode2{CharImp=Zpi} Mode3{CharImp=Zpi} Mode4{CharImp=Zpi}} PhaseDelay=UseScanAngle Phi=0deg Theta=theta_inc LatticeAVector{(-0.16, -0.16, -1) -> (0.16, -0.16, -1)} LatticeBVector{(-0.16, -0.16, -1) -> (-0.16, 0.16, -1)} ModesCalculator{Frequency=1GHz PhiStart=0deg PhiStop=0deg PhiStep=0deg ThetaStart=0deg ThetaStop=0deg ThetaStep=0deg} ModesList{Mode{ModeNumber=1 IndexM=0 IndexN=0 KC2=0 PropagationState=Undefined Attenuation=0 PolarizationState=TE AffectsRefinement} Mode{ModeNumber=2 IndexM=0 IndexN=0 KC2=0 PropagationState=Undefined Attenuation=0 PolarizationState=TM AffectsRefinement} Mode{ModeNumber=3 IndexM=-1 IndexN=0 KC2=385531421917553 PropagationState=Undefined Attenuation=1.7054704e+08 PolarizationState=TE AffectsRefinement} Mode{ModeNumber=4 IndexM=0 IndexN=-1 KC2=385531421917553 PropagationState=Undefined Attenuation=1.7054704e+08 PolarizationState=TE AffectsRefinement}}
setups:
  Setup1: HfssDriven Frequency=666.2THz MaxDeltaS=0.01 MaximumPasses=15 MinimumPasses=1 MinimumConvergedPasses=1 PercentRefinement=30 BasisOrder=1 PortAccuracy=2 DrivenSolverType="Direct Solver"
    sweep Varredura: 187.4THz to 666.2THz, 401 points; Type=Interpolating InterpTolerance=0.5 InterpMaxSolns=250 PassivityErrorTolerance=0.0001
source amplitudes:
  FloquetCima:1: 1W 0deg
  FloquetCima:2, FloquetCima:3, FloquetCima:4, FloquetBaixo:1..FloquetBaixo:4: 0W 0deg

design G0464_anelQ_anelC (HFSS, HFSS Modal Network, model units um)
variables:
  theta_inc = 0deg
geometry:
  Au_anelq [Au_JC] = box(corner=(-0.0845um, -0.0845um, 0um), size=(0.169um, 0.169um, 0.03um))
  Au_anelq_furo = box(corner=(-0.0565um, -0.0565um, 0um), size=(0.113um, 0.113um, 0.03um))
  Au_anelq.subtract(Au_anelq_furo)
  Au_anelc = cylinder(axis=Z, base_centre=(0um, 0um, 0um), radius=0.042um, height=0.03um)
  Au_anelc_furo = cylinder(axis=Z, base_centre=(0um, 0um, 0um), radius=0.023um, height=0.03um)
  Au_anelc.subtract(Au_anelc_furo)
  Au_anelq.unite(Au_anelc)
  Air_Domain [vacuum] = box(corner=(-0.16um, -0.16um, -1um), size=(0.32um, 0.32um, 2.03um))
  Au_anelq_1 = Au_anelq.copy()
  Air_Domain.subtract(Au_anelq_1)
boundaries and excitations:
  LatticePair_2KZX8P: Lattice Pair Faces=Air_Domain.face(-x, +x) CoordSysVector{(-0.16, -0.16, -1) -> (-0.16, -0.16, 1.03)} PhaseDelay=UseScanAngle Phi=0deg Theta=theta_inc
  LatticePair_6JWKL4: Lattice Pair Faces=Air_Domain.face(-y, +y) CoordSysVector{(0.16, -0.16, -1) -> (0.16, -0.16, 1.03)} PhaseDelay=UseScanAngle Phi=0deg Theta=theta_inc
  FloquetCima: Floquet Port Faces=Air_Domain.face(+z) NumModes=4 Modes{Mode1{CharImp=Zpi} Mode2{CharImp=Zpi} Mode3{CharImp=Zpi} Mode4{CharImp=Zpi}} PhaseDelay=UseScanAngle Phi=0deg Theta=theta_inc LatticeAVector{(-0.16, -0.16, 1.03) -> (0.16, -0.16, 1.03)} LatticeBVector{(-0.16, -0.16, 1.03) -> (-0.16, 0.16, 1.03)} ModesCalculator{Frequency=1GHz PhiStart=0deg PhiStop=0deg PhiStep=0deg ThetaStart=0deg ThetaStop=0deg ThetaStep=0deg} ModesList{Mode{ModeNumber=1 IndexM=0 IndexN=0 KC2=0 PropagationState=Undefined Attenuation=0 PolarizationState=TE AffectsRefinement} Mode{ModeNumber=2 IndexM=0 IndexN=0 KC2=0 PropagationState=Undefined Attenuation=0 PolarizationState=TM AffectsRefinement} Mode{ModeNumber=3 IndexM=-1 IndexN=0 KC2=385531421917553 PropagationState=Undefined Attenuation=1.7054704e+08 PolarizationState=TE AffectsRefinement} Mode{ModeNumber=4 IndexM=0 IndexN=-1 KC2=385531421917553 PropagationState=Undefined Attenuation=1.7054704e+08 PolarizationState=TE AffectsRefinement}}
  FloquetBaixo: Floquet Port Faces=Air_Domain.face(-z) NumModes=4 Modes{Mode1{CharImp=Zpi} Mode2{CharImp=Zpi} Mode3{CharImp=Zpi} Mode4{CharImp=Zpi}} PhaseDelay=UseScanAngle Phi=0deg Theta=theta_inc LatticeAVector{(-0.16, -0.16, -1) -> (0.16, -0.16, -1)} LatticeBVector{(-0.16, -0.16, -1) -> (-0.16, 0.16, -1)} ModesCalculator{Frequency=1GHz PhiStart=0deg PhiStop=0deg PhiStep=0deg ThetaStart=0deg ThetaStop=0deg ThetaStep=0deg} ModesList{Mode{ModeNumber=1 IndexM=0 IndexN=0 KC2=0 PropagationState=Undefined Attenuation=0 PolarizationState=TE AffectsRefinement} Mode{ModeNumber=2 IndexM=0 IndexN=0 KC2=0 PropagationState=Undefined Attenuation=0 PolarizationState=TM AffectsRefinement} Mode{ModeNumber=3 IndexM=-1 IndexN=0 KC2=385531421917553 PropagationState=Undefined Attenuation=1.7054704e+08 PolarizationState=TE AffectsRefinement} Mode{ModeNumber=4 IndexM=0 IndexN=-1 KC2=385531421917553 PropagationState=Undefined Attenuation=1.7054704e+08 PolarizationState=TE AffectsRefinement}}
setups:
  Setup1: HfssDriven Frequency=666.2THz MaxDeltaS=0.01 MaximumPasses=15 MinimumPasses=1 MinimumConvergedPasses=1 PercentRefinement=30 BasisOrder=1 PortAccuracy=2 DrivenSolverType="Direct Solver"
    sweep Varredura: 187.4THz to 666.2THz, 401 points; Type=Interpolating InterpTolerance=0.5 InterpMaxSolns=250 PassivityErrorTolerance=0.0001
source amplitudes:
  FloquetCima:1: 1W 0deg
  FloquetCima:2, FloquetCima:3, FloquetCima:4, FloquetBaixo:1..FloquetBaixo:4: 0W 0deg

design G0553_anelQ_anelC (HFSS, HFSS Modal Network, model units um)
variables:
  theta_inc = 0deg
geometry:
  Au_anelq [Au_JC] = box(corner=(-0.1105um, -0.1105um, 0um), size=(0.221um, 0.221um, 0.03um))
  Au_anelq_furo = box(corner=(-0.0695um, -0.0695um, 0um), size=(0.139um, 0.139um, 0.03um))
  Au_anelq.subtract(Au_anelq_furo)
  Au_anelc = cylinder(axis=Z, base_centre=(0um, 0um, 0um), radius=0.057um, height=0.03um)
  Au_anelc_furo = cylinder(axis=Z, base_centre=(0um, 0um, 0um), radius=0.026um, height=0.03um)
  Au_anelc.subtract(Au_anelc_furo)
  Au_anelq.unite(Au_anelc)
  Air_Domain [vacuum] = box(corner=(-0.16um, -0.16um, -1um), size=(0.32um, 0.32um, 2.03um))
  Au_anelq_1 = Au_anelq.copy()
  Air_Domain.subtract(Au_anelq_1)
boundaries and excitations:
  LatticePair_V985DR: Lattice Pair Faces=Air_Domain.face(-x, +x) CoordSysVector{(-0.16, -0.16, -1) -> (-0.16, -0.16, 1.03)} PhaseDelay=UseScanAngle Phi=0deg Theta=theta_inc
  LatticePair_J0ERYO: Lattice Pair Faces=Air_Domain.face(-y, +y) CoordSysVector{(0.16, -0.16, -1) -> (0.16, -0.16, 1.03)} PhaseDelay=UseScanAngle Phi=0deg Theta=theta_inc
  FloquetCima: Floquet Port Faces=Air_Domain.face(+z) NumModes=4 Modes{Mode1{CharImp=Zpi} Mode2{CharImp=Zpi} Mode3{CharImp=Zpi} Mode4{CharImp=Zpi}} PhaseDelay=UseScanAngle Phi=0deg Theta=theta_inc LatticeAVector{(-0.16, -0.16, 1.03) -> (0.16, -0.16, 1.03)} LatticeBVector{(-0.16, -0.16, 1.03) -> (-0.16, 0.16, 1.03)} ModesCalculator{Frequency=1GHz PhiStart=0deg PhiStop=0deg PhiStep=0deg ThetaStart=0deg ThetaStop=0deg ThetaStep=0deg} ModesList{Mode{ModeNumber=1 IndexM=0 IndexN=0 KC2=0 PropagationState=Undefined Attenuation=0 PolarizationState=TE AffectsRefinement} Mode{ModeNumber=2 IndexM=0 IndexN=0 KC2=0 PropagationState=Undefined Attenuation=0 PolarizationState=TM AffectsRefinement} Mode{ModeNumber=3 IndexM=-1 IndexN=0 KC2=385531421917553 PropagationState=Undefined Attenuation=1.7054704e+08 PolarizationState=TE AffectsRefinement} Mode{ModeNumber=4 IndexM=0 IndexN=-1 KC2=385531421917553 PropagationState=Undefined Attenuation=1.7054704e+08 PolarizationState=TE AffectsRefinement}}
  FloquetBaixo: Floquet Port Faces=Air_Domain.face(-z) NumModes=4 Modes{Mode1{CharImp=Zpi} Mode2{CharImp=Zpi} Mode3{CharImp=Zpi} Mode4{CharImp=Zpi}} PhaseDelay=UseScanAngle Phi=0deg Theta=theta_inc LatticeAVector{(-0.16, -0.16, -1) -> (0.16, -0.16, -1)} LatticeBVector{(-0.16, -0.16, -1) -> (-0.16, 0.16, -1)} ModesCalculator{Frequency=1GHz PhiStart=0deg PhiStop=0deg PhiStep=0deg ThetaStart=0deg ThetaStop=0deg ThetaStep=0deg} ModesList{Mode{ModeNumber=1 IndexM=0 IndexN=0 KC2=0 PropagationState=Undefined Attenuation=0 PolarizationState=TE AffectsRefinement} Mode{ModeNumber=2 IndexM=0 IndexN=0 KC2=0 PropagationState=Undefined Attenuation=0 PolarizationState=TM AffectsRefinement} Mode{ModeNumber=3 IndexM=-1 IndexN=0 KC2=385531421917553 PropagationState=Undefined Attenuation=1.7054704e+08 PolarizationState=TE AffectsRefinement} Mode{ModeNumber=4 IndexM=0 IndexN=-1 KC2=385531421917553 PropagationState=Undefined Attenuation=1.7054704e+08 PolarizationState=TE AffectsRefinement}}
setups:
  Setup1: HfssDriven Frequency=666.2THz MaxDeltaS=0.01 MaximumPasses=15 MinimumPasses=1 MinimumConvergedPasses=1 PercentRefinement=30 BasisOrder=1 PortAccuracy=2 DrivenSolverType="Direct Solver"
    sweep Varredura: 187.4THz to 666.2THz, 401 points; Type=Interpolating InterpTolerance=0.5 InterpMaxSolns=250 PassivityErrorTolerance=0.0001
source amplitudes:
  FloquetCima:1: 1W 0deg
  FloquetCima:2, FloquetCima:3, FloquetCima:4, FloquetBaixo:1..FloquetBaixo:4: 0W 0deg

design G0798_anelQ_anelC_trilhas (HFSS, HFSS Modal Network, model units um)
variables:
  theta_inc = 0deg
geometry:
  Au_anelq [Au_JC] = box(corner=(-0.104um, -0.104um, 0um), size=(0.208um, 0.208um, 0.03um))
  Au_anelq_furo = box(corner=(-0.055um, -0.055um, 0um), size=(0.11um, 0.11um, 0.03um))
  Au_anelq.subtract(Au_anelq_furo)
  Au_anelc = cylinder(axis=Z, base_centre=(0um, 0um, 0um), radius=0.045um, height=0.03um)
  Au_anelc_furo = cylinder(axis=Z, base_centre=(0um, 0um, 0um), radius=0.025um, height=0.03um)
  Au_anelc.subtract(Au_anelc_furo)
  Au_trilha0 = box(corner=(0.015um, -0.012um, 0um), size=(0.0645um, 0.024um, 0.03um))
  Au_trilha1 = box(corner=(-0.0795um, -0.012um, 0um), size=(0.0645um, 0.024um, 0.03um))
  Au_trilha2 = box(corner=(-0.012um, 0.015um, 0um), size=(0.024um, 0.0645um, 0.03um))
  Au_trilha3 = box(corner=(-0.012um, -0.0795um, 0um), size=(0.024um, 0.0645um, 0.03um))
  Au_anelq.unite(Au_anelc, Au_trilha0..Au_trilha3)
  Air_Domain [vacuum] = box(corner=(-0.16um, -0.16um, -1um), size=(0.32um, 0.32um, 2.03um))
  Au_anelq_1 = Au_anelq.copy()
  Air_Domain.subtract(Au_anelq_1)
boundaries and excitations:
  LatticePair_2SCC86: Lattice Pair Faces=Air_Domain.face(-x, +x) CoordSysVector{(-0.16, -0.16, -1) -> (-0.16, -0.16, 1.03)} PhaseDelay=UseScanAngle Phi=0deg Theta=theta_inc
  LatticePair_UDHSX8: Lattice Pair Faces=Air_Domain.face(-y, +y) CoordSysVector{(0.16, -0.16, -1) -> (0.16, -0.16, 1.03)} PhaseDelay=UseScanAngle Phi=0deg Theta=theta_inc
  FloquetCima: Floquet Port Faces=Air_Domain.face(+z) NumModes=4 Modes{Mode1{CharImp=Zpi} Mode2{CharImp=Zpi} Mode3{CharImp=Zpi} Mode4{CharImp=Zpi}} PhaseDelay=UseScanAngle Phi=0deg Theta=theta_inc LatticeAVector{(-0.16, -0.16, 1.03) -> (0.16, -0.16, 1.03)} LatticeBVector{(-0.16, -0.16, 1.03) -> (-0.16, 0.16, 1.03)} ModesCalculator{Frequency=1GHz PhiStart=0deg PhiStop=0deg PhiStep=0deg ThetaStart=0deg ThetaStop=0deg ThetaStep=0deg} ModesList{Mode{ModeNumber=1 IndexM=0 IndexN=0 KC2=0 PropagationState=Undefined Attenuation=0 PolarizationState=TE AffectsRefinement} Mode{ModeNumber=2 IndexM=0 IndexN=0 KC2=0 PropagationState=Undefined Attenuation=0 PolarizationState=TM AffectsRefinement} Mode{ModeNumber=3 IndexM=-1 IndexN=0 KC2=385531421917553 PropagationState=Undefined Attenuation=1.7054704e+08 PolarizationState=TE AffectsRefinement} Mode{ModeNumber=4 IndexM=0 IndexN=-1 KC2=385531421917553 PropagationState=Undefined Attenuation=1.7054704e+08 PolarizationState=TE AffectsRefinement}}
  FloquetBaixo: Floquet Port Faces=Air_Domain.face(-z) NumModes=4 Modes{Mode1{CharImp=Zpi} Mode2{CharImp=Zpi} Mode3{CharImp=Zpi} Mode4{CharImp=Zpi}} PhaseDelay=UseScanAngle Phi=0deg Theta=theta_inc LatticeAVector{(-0.16, -0.16, -1) -> (0.16, -0.16, -1)} LatticeBVector{(-0.16, -0.16, -1) -> (-0.16, 0.16, -1)} ModesCalculator{Frequency=1GHz PhiStart=0deg PhiStop=0deg PhiStep=0deg ThetaStart=0deg ThetaStop=0deg ThetaStep=0deg} ModesList{Mode{ModeNumber=1 IndexM=0 IndexN=0 KC2=0 PropagationState=Undefined Attenuation=0 PolarizationState=TE AffectsRefinement} Mode{ModeNumber=2 IndexM=0 IndexN=0 KC2=0 PropagationState=Undefined Attenuation=0 PolarizationState=TM AffectsRefinement} Mode{ModeNumber=3 IndexM=-1 IndexN=0 KC2=385531421917553 PropagationState=Undefined Attenuation=1.7054704e+08 PolarizationState=TE AffectsRefinement} Mode{ModeNumber=4 IndexM=0 IndexN=-1 KC2=385531421917553 PropagationState=Undefined Attenuation=1.7054704e+08 PolarizationState=TE AffectsRefinement}}
setups:
  Setup1: HfssDriven Frequency=666.2THz MaxDeltaS=0.01 MaximumPasses=15 MinimumPasses=1 MinimumConvergedPasses=1 PercentRefinement=30 BasisOrder=1 PortAccuracy=2 DrivenSolverType="Direct Solver"
    sweep Varredura: 187.4THz to 666.2THz, 401 points; Type=Interpolating InterpTolerance=0.5 InterpMaxSolns=250 PassivityErrorTolerance=0.0001
source amplitudes:
  FloquetCima:1: 1W 0deg
  FloquetCima:2, FloquetCima:3, FloquetCima:4, FloquetBaixo:1..FloquetBaixo:4: 0W 0deg

design G0784_anelQ_anelC_trilhas (HFSS, HFSS Modal Network, model units um)
variables:
  theta_inc = 0deg
geometry:
  Au_anelq [Au_JC] = box(corner=(-0.0985um, -0.0985um, 0um), size=(0.197um, 0.197um, 0.03um))
  Au_anelq_furo = box(corner=(-0.0555um, -0.0555um, 0um), size=(0.111um, 0.111um, 0.03um))
  Au_anelq.subtract(Au_anelq_furo)
  Au_anelc = cylinder(axis=Z, base_centre=(0um, 0um, 0um), radius=0.038um, height=0.03um)
  Au_anelc_furo = cylinder(axis=Z, base_centre=(0um, 0um, 0um), radius=0.017um, height=0.03um)
  Au_anelc.subtract(Au_anelc_furo)
  Au_trilha0 = box(corner=(0.007um, -0.0125um, 0um), size=(0.07um, 0.025um, 0.03um))
  Au_trilha1 = box(corner=(-0.077um, -0.0125um, 0um), size=(0.07um, 0.025um, 0.03um))
  Au_trilha2 = box(corner=(-0.0125um, 0.007um, 0um), size=(0.025um, 0.07um, 0.03um))
  Au_trilha3 = box(corner=(-0.0125um, -0.077um, 0um), size=(0.025um, 0.07um, 0.03um))
  Au_anelq.unite(Au_anelc, Au_trilha0..Au_trilha3)
  Air_Domain [vacuum] = box(corner=(-0.16um, -0.16um, -1um), size=(0.32um, 0.32um, 2.03um))
  Au_anelq_1 = Au_anelq.copy()
  Air_Domain.subtract(Au_anelq_1)
boundaries and excitations:
  LatticePair_55V14K: Lattice Pair Faces=Air_Domain.face(-x, +x) CoordSysVector{(-0.16, -0.16, -1) -> (-0.16, -0.16, 1.03)} PhaseDelay=UseScanAngle Phi=0deg Theta=theta_inc
  LatticePair_C12889: Lattice Pair Faces=Air_Domain.face(-y, +y) CoordSysVector{(0.16, -0.16, -1) -> (0.16, -0.16, 1.03)} PhaseDelay=UseScanAngle Phi=0deg Theta=theta_inc
  FloquetCima: Floquet Port Faces=Air_Domain.face(+z) NumModes=4 Modes{Mode1{CharImp=Zpi} Mode2{CharImp=Zpi} Mode3{CharImp=Zpi} Mode4{CharImp=Zpi}} PhaseDelay=UseScanAngle Phi=0deg Theta=theta_inc LatticeAVector{(-0.16, -0.16, 1.03) -> (0.16, -0.16, 1.03)} LatticeBVector{(-0.16, -0.16, 1.03) -> (-0.16, 0.16, 1.03)} ModesCalculator{Frequency=1GHz PhiStart=0deg PhiStop=0deg PhiStep=0deg ThetaStart=0deg ThetaStop=0deg ThetaStep=0deg} ModesList{Mode{ModeNumber=1 IndexM=0 IndexN=0 KC2=0 PropagationState=Undefined Attenuation=0 PolarizationState=TE AffectsRefinement} Mode{ModeNumber=2 IndexM=0 IndexN=0 KC2=0 PropagationState=Undefined Attenuation=0 PolarizationState=TM AffectsRefinement} Mode{ModeNumber=3 IndexM=-1 IndexN=0 KC2=385531421917553 PropagationState=Undefined Attenuation=1.7054704e+08 PolarizationState=TE AffectsRefinement} Mode{ModeNumber=4 IndexM=0 IndexN=-1 KC2=385531421917553 PropagationState=Undefined Attenuation=1.7054704e+08 PolarizationState=TE AffectsRefinement}}
  FloquetBaixo: Floquet Port Faces=Air_Domain.face(-z) NumModes=4 Modes{Mode1{CharImp=Zpi} Mode2{CharImp=Zpi} Mode3{CharImp=Zpi} Mode4{CharImp=Zpi}} PhaseDelay=UseScanAngle Phi=0deg Theta=theta_inc LatticeAVector{(-0.16, -0.16, -1) -> (0.16, -0.16, -1)} LatticeBVector{(-0.16, -0.16, -1) -> (-0.16, 0.16, -1)} ModesCalculator{Frequency=1GHz PhiStart=0deg PhiStop=0deg PhiStep=0deg ThetaStart=0deg ThetaStop=0deg ThetaStep=0deg} ModesList{Mode{ModeNumber=1 IndexM=0 IndexN=0 KC2=0 PropagationState=Undefined Attenuation=0 PolarizationState=TE AffectsRefinement} Mode{ModeNumber=2 IndexM=0 IndexN=0 KC2=0 PropagationState=Undefined Attenuation=0 PolarizationState=TM AffectsRefinement} Mode{ModeNumber=3 IndexM=-1 IndexN=0 KC2=385531421917553 PropagationState=Undefined Attenuation=1.7054704e+08 PolarizationState=TE AffectsRefinement} Mode{ModeNumber=4 IndexM=0 IndexN=-1 KC2=385531421917553 PropagationState=Undefined Attenuation=1.7054704e+08 PolarizationState=TE AffectsRefinement}}
setups:
  Setup1: HfssDriven Frequency=666.2THz MaxDeltaS=0.01 MaximumPasses=15 MinimumPasses=1 MinimumConvergedPasses=1 PercentRefinement=30 BasisOrder=1 PortAccuracy=2 DrivenSolverType="Direct Solver"
    sweep Varredura: 187.4THz to 666.2THz, 401 points; Type=Interpolating InterpTolerance=0.5 InterpMaxSolns=250 PassivityErrorTolerance=0.0001
source amplitudes:
  FloquetCima:1: 1W 0deg
  FloquetCima:2, FloquetCima:3, FloquetCima:4, FloquetBaixo:1..FloquetBaixo:4: 0W 0deg

design G0767_anelQ_anelC_trilhas (HFSS, HFSS Modal Network, model units um)
variables:
  theta_inc = 0deg
geometry:
  Au_anelq [Au_JC] = box(corner=(-0.1025um, -0.1025um, 0um), size=(0.205um, 0.205um, 0.03um))
  Au_anelq_furo = box(corner=(-0.0545um, -0.0545um, 0um), size=(0.109um, 0.109um, 0.03um))
  Au_anelq.subtract(Au_anelq_furo)
  Au_anelc = cylinder(axis=Z, base_centre=(0um, 0um, 0um), radius=0.036um, height=0.03um)
  Au_anelc_furo = cylinder(axis=Z, base_centre=(0um, 0um, 0um), radius=0.015um, height=0.03um)
  Au_anelc.subtract(Au_anelc_furo)
  Au_trilha0 = box(corner=(0.005um, -0.013um, 0um), size=(0.0735um, 0.026um, 0.03um))
  Au_trilha1 = box(corner=(-0.0785um, -0.013um, 0um), size=(0.0735um, 0.026um, 0.03um))
  Au_trilha2 = box(corner=(-0.013um, 0.005um, 0um), size=(0.026um, 0.0735um, 0.03um))
  Au_trilha3 = box(corner=(-0.013um, -0.0785um, 0um), size=(0.026um, 0.0735um, 0.03um))
  Au_anelq.unite(Au_anelc, Au_trilha0..Au_trilha3)
  Air_Domain [vacuum] = box(corner=(-0.16um, -0.16um, -1um), size=(0.32um, 0.32um, 2.03um))
  Au_anelq_1 = Au_anelq.copy()
  Air_Domain.subtract(Au_anelq_1)
boundaries and excitations:
  LatticePair_DCLBU5: Lattice Pair Faces=Air_Domain.face(-x, +x) CoordSysVector{(-0.16, -0.16, -1) -> (-0.16, -0.16, 1.03)} PhaseDelay=UseScanAngle Phi=0deg Theta=theta_inc
  LatticePair_4YVRDQ: Lattice Pair Faces=Air_Domain.face(-y, +y) CoordSysVector{(0.16, -0.16, -1) -> (0.16, -0.16, 1.03)} PhaseDelay=UseScanAngle Phi=0deg Theta=theta_inc
  FloquetCima: Floquet Port Faces=Air_Domain.face(+z) NumModes=4 Modes{Mode1{CharImp=Zpi} Mode2{CharImp=Zpi} Mode3{CharImp=Zpi} Mode4{CharImp=Zpi}} PhaseDelay=UseScanAngle Phi=0deg Theta=theta_inc LatticeAVector{(-0.16, -0.16, 1.03) -> (0.16, -0.16, 1.03)} LatticeBVector{(-0.16, -0.16, 1.03) -> (-0.16, 0.16, 1.03)} ModesCalculator{Frequency=1GHz PhiStart=0deg PhiStop=0deg PhiStep=0deg ThetaStart=0deg ThetaStop=0deg ThetaStep=0deg} ModesList{Mode{ModeNumber=1 IndexM=0 IndexN=0 KC2=0 PropagationState=Undefined Attenuation=0 PolarizationState=TE AffectsRefinement} Mode{ModeNumber=2 IndexM=0 IndexN=0 KC2=0 PropagationState=Undefined Attenuation=0 PolarizationState=TM AffectsRefinement} Mode{ModeNumber=3 IndexM=-1 IndexN=0 KC2=385531421917553 PropagationState=Undefined Attenuation=1.7054704e+08 PolarizationState=TE AffectsRefinement} Mode{ModeNumber=4 IndexM=0 IndexN=-1 KC2=385531421917553 PropagationState=Undefined Attenuation=1.7054704e+08 PolarizationState=TE AffectsRefinement}}
  FloquetBaixo: Floquet Port Faces=Air_Domain.face(-z) NumModes=4 Modes{Mode1{CharImp=Zpi} Mode2{CharImp=Zpi} Mode3{CharImp=Zpi} Mode4{CharImp=Zpi}} PhaseDelay=UseScanAngle Phi=0deg Theta=theta_inc LatticeAVector{(-0.16, -0.16, -1) -> (0.16, -0.16, -1)} LatticeBVector{(-0.16, -0.16, -1) -> (-0.16, 0.16, -1)} ModesCalculator{Frequency=1GHz PhiStart=0deg PhiStop=0deg PhiStep=0deg ThetaStart=0deg ThetaStop=0deg ThetaStep=0deg} ModesList{Mode{ModeNumber=1 IndexM=0 IndexN=0 KC2=0 PropagationState=Undefined Attenuation=0 PolarizationState=TE AffectsRefinement} Mode{ModeNumber=2 IndexM=0 IndexN=0 KC2=0 PropagationState=Undefined Attenuation=0 PolarizationState=TM AffectsRefinement} Mode{ModeNumber=3 IndexM=-1 IndexN=0 KC2=385531421917553 PropagationState=Undefined Attenuation=1.7054704e+08 PolarizationState=TE AffectsRefinement} Mode{ModeNumber=4 IndexM=0 IndexN=-1 KC2=385531421917553 PropagationState=Undefined Attenuation=1.7054704e+08 PolarizationState=TE AffectsRefinement}}
setups:
  Setup1: HfssDriven Frequency=666.2THz MaxDeltaS=0.01 MaximumPasses=15 MinimumPasses=1 MinimumConvergedPasses=1 PercentRefinement=30 BasisOrder=1 PortAccuracy=2 DrivenSolverType="Direct Solver"
    sweep Varredura: 187.4THz to 666.2THz, 401 points; Type=Interpolating InterpTolerance=0.5 InterpMaxSolns=250 PassivityErrorTolerance=0.0001
source amplitudes:
  FloquetCima:1: 1W 0deg
  FloquetCima:2, FloquetCima:3, FloquetCima:4, FloquetBaixo:1..FloquetBaixo:4: 0W 0deg

design G0732_anelQ_anelC_trilhas (HFSS, HFSS Modal Network, model units um)
variables:
  theta_inc = 0deg
geometry:
  Au_anelq [Au_JC] = box(corner=(-0.115um, -0.115um, 0um), size=(0.23um, 0.23um, 0.03um))
  Au_anelq_furo = box(corner=(-0.077um, -0.077um, 0um), size=(0.154um, 0.154um, 0.03um))
  Au_anelq.subtract(Au_anelq_furo)
  Au_anelc = cylinder(axis=Z, base_centre=(0um, 0um, 0um), radius=0.059um, height=0.03um)
  Au_anelc_furo = cylinder(axis=Z, base_centre=(0um, 0um, 0um), radius=0.026um, height=0.03um)
  Au_anelc.subtract(Au_anelc_furo)
  Au_trilha0 = box(corner=(0.016um, -0.0085um, 0um), size=(0.08um, 0.017um, 0.03um))
  Au_trilha1 = box(corner=(-0.096um, -0.0085um, 0um), size=(0.08um, 0.017um, 0.03um))
  Au_trilha2 = box(corner=(-0.0085um, 0.016um, 0um), size=(0.017um, 0.08um, 0.03um))
  Au_trilha3 = box(corner=(-0.0085um, -0.096um, 0um), size=(0.017um, 0.08um, 0.03um))
  Au_anelq.unite(Au_anelc, Au_trilha0..Au_trilha3)
  Air_Domain [vacuum] = box(corner=(-0.16um, -0.16um, -1um), size=(0.32um, 0.32um, 2.03um))
  Au_anelq_1 = Au_anelq.copy()
  Air_Domain.subtract(Au_anelq_1)
boundaries and excitations:
  LatticePair_8U7THC: Lattice Pair Faces=Air_Domain.face(-x, +x) CoordSysVector{(-0.16, -0.16, -1) -> (-0.16, -0.16, 1.03)} PhaseDelay=UseScanAngle Phi=0deg Theta=theta_inc
  LatticePair_KH2RC3: Lattice Pair Faces=Air_Domain.face(-y, +y) CoordSysVector{(0.16, -0.16, -1) -> (0.16, -0.16, 1.03)} PhaseDelay=UseScanAngle Phi=0deg Theta=theta_inc
  FloquetCima: Floquet Port Faces=Air_Domain.face(+z) NumModes=4 Modes{Mode1{CharImp=Zpi} Mode2{CharImp=Zpi} Mode3{CharImp=Zpi} Mode4{CharImp=Zpi}} PhaseDelay=UseScanAngle Phi=0deg Theta=theta_inc LatticeAVector{(-0.16, -0.16, 1.03) -> (0.16, -0.16, 1.03)} LatticeBVector{(-0.16, -0.16, 1.03) -> (-0.16, 0.16, 1.03)} ModesCalculator{Frequency=1GHz PhiStart=0deg PhiStop=0deg PhiStep=0deg ThetaStart=0deg ThetaStop=0deg ThetaStep=0deg} ModesList{Mode{ModeNumber=1 IndexM=0 IndexN=0 KC2=0 PropagationState=Undefined Attenuation=0 PolarizationState=TE AffectsRefinement} Mode{ModeNumber=2 IndexM=0 IndexN=0 KC2=0 PropagationState=Undefined Attenuation=0 PolarizationState=TM AffectsRefinement} Mode{ModeNumber=3 IndexM=-1 IndexN=0 KC2=385531421917553 PropagationState=Undefined Attenuation=1.7054704e+08 PolarizationState=TE AffectsRefinement} Mode{ModeNumber=4 IndexM=0 IndexN=-1 KC2=385531421917553 PropagationState=Undefined Attenuation=1.7054704e+08 PolarizationState=TE AffectsRefinement}}
  FloquetBaixo: Floquet Port Faces=Air_Domain.face(-z) NumModes=4 Modes{Mode1{CharImp=Zpi} Mode2{CharImp=Zpi} Mode3{CharImp=Zpi} Mode4{CharImp=Zpi}} PhaseDelay=UseScanAngle Phi=0deg Theta=theta_inc LatticeAVector{(-0.16, -0.16, -1) -> (0.16, -0.16, -1)} LatticeBVector{(-0.16, -0.16, -1) -> (-0.16, 0.16, -1)} ModesCalculator{Frequency=1GHz PhiStart=0deg PhiStop=0deg PhiStep=0deg ThetaStart=0deg ThetaStop=0deg ThetaStep=0deg} ModesList{Mode{ModeNumber=1 IndexM=0 IndexN=0 KC2=0 PropagationState=Undefined Attenuation=0 PolarizationState=TE AffectsRefinement} Mode{ModeNumber=2 IndexM=0 IndexN=0 KC2=0 PropagationState=Undefined Attenuation=0 PolarizationState=TM AffectsRefinement} Mode{ModeNumber=3 IndexM=-1 IndexN=0 KC2=385531421917553 PropagationState=Undefined Attenuation=1.7054704e+08 PolarizationState=TE AffectsRefinement} Mode{ModeNumber=4 IndexM=0 IndexN=-1 KC2=385531421917553 PropagationState=Undefined Attenuation=1.7054704e+08 PolarizationState=TE AffectsRefinement}}
setups:
  Setup1: HfssDriven Frequency=666.2THz MaxDeltaS=0.01 MaximumPasses=15 MinimumPasses=1 MinimumConvergedPasses=1 PercentRefinement=30 BasisOrder=1 PortAccuracy=2 DrivenSolverType="Direct Solver"
    sweep Varredura: 187.4THz to 666.2THz, 401 points; Type=Interpolating InterpTolerance=0.5 InterpMaxSolns=250 PassivityErrorTolerance=0.0001
source amplitudes:
  FloquetCima:1: 1W 0deg
  FloquetCima:2, FloquetCima:3, FloquetCima:4, FloquetBaixo:1..FloquetBaixo:4: 0W 0deg

design G0664_anelQ_anelC_trilhas (HFSS, HFSS Modal Network, model units um)
variables:
  theta_inc = 0deg
geometry:
  Au_anelq [Au_JC] = box(corner=(-0.119um, -0.119um, 0um), size=(0.238um, 0.238um, 0.03um))
  Au_anelq_furo = box(corner=(-0.09um, -0.09um, 0um), size=(0.18um, 0.18um, 0.03um))
  Au_anelq.subtract(Au_anelq_furo)
  Au_anelc = cylinder(axis=Z, base_centre=(0um, 0um, 0um), radius=0.073um, height=0.03um)
  Au_anelc_furo = cylinder(axis=Z, base_centre=(0um, 0um, 0um), radius=0.054um, height=0.03um)
  Au_anelc.subtract(Au_anelc_furo)
  Au_trilha0 = box(corner=(0.044um, -0.009um, 0um), size=(0.0605um, 0.018um, 0.03um))
  Au_trilha1 = box(corner=(-0.1045um, -0.009um, 0um), size=(0.0605um, 0.018um, 0.03um))
  Au_trilha2 = box(corner=(-0.009um, 0.044um, 0um), size=(0.018um, 0.0605um, 0.03um))
  Au_trilha3 = box(corner=(-0.009um, -0.1045um, 0um), size=(0.018um, 0.0605um, 0.03um))
  Au_anelq.unite(Au_anelc, Au_trilha0..Au_trilha3)
  Air_Domain [vacuum] = box(corner=(-0.16um, -0.16um, -1um), size=(0.32um, 0.32um, 2.03um))
  Au_anelq_1 = Au_anelq.copy()
  Air_Domain.subtract(Au_anelq_1)
boundaries and excitations:
  LatticePair_IGW2FW: Lattice Pair Faces=Air_Domain.face(-x, +x) CoordSysVector{(-0.16, -0.16, -1) -> (-0.16, -0.16, 1.03)} PhaseDelay=UseScanAngle Phi=0deg Theta=theta_inc
  LatticePair_I2Q6QV: Lattice Pair Faces=Air_Domain.face(-y, +y) CoordSysVector{(0.16, -0.16, -1) -> (0.16, -0.16, 1.03)} PhaseDelay=UseScanAngle Phi=0deg Theta=theta_inc
  FloquetCima: Floquet Port Faces=Air_Domain.face(+z) NumModes=4 Modes{Mode1{CharImp=Zpi} Mode2{CharImp=Zpi} Mode3{CharImp=Zpi} Mode4{CharImp=Zpi}} PhaseDelay=UseScanAngle Phi=0deg Theta=theta_inc LatticeAVector{(-0.16, -0.16, 1.03) -> (0.16, -0.16, 1.03)} LatticeBVector{(-0.16, -0.16, 1.03) -> (-0.16, 0.16, 1.03)} ModesCalculator{Frequency=1GHz PhiStart=0deg PhiStop=0deg PhiStep=0deg ThetaStart=0deg ThetaStop=0deg ThetaStep=0deg} ModesList{Mode{ModeNumber=1 IndexM=0 IndexN=0 KC2=0 PropagationState=Undefined Attenuation=0 PolarizationState=TE AffectsRefinement} Mode{ModeNumber=2 IndexM=0 IndexN=0 KC2=0 PropagationState=Undefined Attenuation=0 PolarizationState=TM AffectsRefinement} Mode{ModeNumber=3 IndexM=-1 IndexN=0 KC2=385531421917553 PropagationState=Undefined Attenuation=1.7054704e+08 PolarizationState=TE AffectsRefinement} Mode{ModeNumber=4 IndexM=0 IndexN=-1 KC2=385531421917553 PropagationState=Undefined Attenuation=1.7054704e+08 PolarizationState=TE AffectsRefinement}}
  FloquetBaixo: Floquet Port Faces=Air_Domain.face(-z) NumModes=4 Modes{Mode1{CharImp=Zpi} Mode2{CharImp=Zpi} Mode3{CharImp=Zpi} Mode4{CharImp=Zpi}} PhaseDelay=UseScanAngle Phi=0deg Theta=theta_inc LatticeAVector{(-0.16, -0.16, -1) -> (0.16, -0.16, -1)} LatticeBVector{(-0.16, -0.16, -1) -> (-0.16, 0.16, -1)} ModesCalculator{Frequency=1GHz PhiStart=0deg PhiStop=0deg PhiStep=0deg ThetaStart=0deg ThetaStop=0deg ThetaStep=0deg} ModesList{Mode{ModeNumber=1 IndexM=0 IndexN=0 KC2=0 PropagationState=Undefined Attenuation=0 PolarizationState=TE AffectsRefinement} Mode{ModeNumber=2 IndexM=0 IndexN=0 KC2=0 PropagationState=Undefined Attenuation=0 PolarizationState=TM AffectsRefinement} Mode{ModeNumber=3 IndexM=-1 IndexN=0 KC2=385531421917553 PropagationState=Undefined Attenuation=1.7054704e+08 PolarizationState=TE AffectsRefinement} Mode{ModeNumber=4 IndexM=0 IndexN=-1 KC2=385531421917553 PropagationState=Undefined Attenuation=1.7054704e+08 PolarizationState=TE AffectsRefinement}}
setups:
  Setup1: HfssDriven Frequency=666.2THz MaxDeltaS=0.01 MaximumPasses=15 MinimumPasses=1 MinimumConvergedPasses=1 PercentRefinement=30 BasisOrder=1 PortAccuracy=2 DrivenSolverType="Direct Solver"
    sweep Varredura: 187.4THz to 666.2THz, 401 points; Type=Interpolating InterpTolerance=0.5 InterpMaxSolns=250 PassivityErrorTolerance=0.0001
source amplitudes:
  FloquetCima:1: 1W 0deg
  FloquetCima:2, FloquetCima:3, FloquetCima:4, FloquetBaixo:1..FloquetBaixo:4: 0W 0deg

design G0765_anelQ_anelC_trilhas (HFSS, HFSS Modal Network, model units um)
variables:
  theta_inc = 0deg
geometry:
  Au_anelq [Au_JC] = box(corner=(-0.116um, -0.116um, 0um), size=(0.232um, 0.232um, 0.03um))
  Au_anelq_furo = box(corner=(-0.081um, -0.081um, 0um), size=(0.162um, 0.162um, 0.03um))
  Au_anelq.subtract(Au_anelq_furo)
  Au_anelc = cylinder(axis=Z, base_centre=(0um, 0um, 0um), radius=0.058um, height=0.03um)
  Au_anelc_furo = cylinder(axis=Z, base_centre=(0um, 0um, 0um), radius=0.033um, height=0.03um)
  Au_anelc.subtract(Au_anelc_furo)
  Au_trilha0 = box(corner=(0.023um, -0.011um, 0um), size=(0.0755um, 0.022um, 0.03um))
  Au_trilha1 = box(corner=(-0.0985um, -0.011um, 0um), size=(0.0755um, 0.022um, 0.03um))
  Au_trilha2 = box(corner=(-0.011um, 0.023um, 0um), size=(0.022um, 0.0755um, 0.03um))
  Au_trilha3 = box(corner=(-0.011um, -0.0985um, 0um), size=(0.022um, 0.0755um, 0.03um))
  Au_anelq.unite(Au_anelc, Au_trilha0..Au_trilha3)
  Air_Domain [vacuum] = box(corner=(-0.16um, -0.16um, -1um), size=(0.32um, 0.32um, 2.03um))
  Au_anelq_1 = Au_anelq.copy()
  Air_Domain.subtract(Au_anelq_1)
boundaries and excitations:
  LatticePair_2HT525: Lattice Pair Faces=Air_Domain.face(-x, +x) CoordSysVector{(-0.16, -0.16, -1) -> (-0.16, -0.16, 1.03)} PhaseDelay=UseScanAngle Phi=0deg Theta=theta_inc
  LatticePair_GT4DNQ: Lattice Pair Faces=Air_Domain.face(-y, +y) CoordSysVector{(0.16, -0.16, -1) -> (0.16, -0.16, 1.03)} PhaseDelay=UseScanAngle Phi=0deg Theta=theta_inc
  FloquetCima: Floquet Port Faces=Air_Domain.face(+z) NumModes=4 Modes{Mode1{CharImp=Zpi} Mode2{CharImp=Zpi} Mode3{CharImp=Zpi} Mode4{CharImp=Zpi}} PhaseDelay=UseScanAngle Phi=0deg Theta=theta_inc LatticeAVector{(-0.16, -0.16, 1.03) -> (0.16, -0.16, 1.03)} LatticeBVector{(-0.16, -0.16, 1.03) -> (-0.16, 0.16, 1.03)} ModesCalculator{Frequency=1GHz PhiStart=0deg PhiStop=0deg PhiStep=0deg ThetaStart=0deg ThetaStop=0deg ThetaStep=0deg} ModesList{Mode{ModeNumber=1 IndexM=0 IndexN=0 KC2=0 PropagationState=Undefined Attenuation=0 PolarizationState=TE AffectsRefinement} Mode{ModeNumber=2 IndexM=0 IndexN=0 KC2=0 PropagationState=Undefined Attenuation=0 PolarizationState=TM AffectsRefinement} Mode{ModeNumber=3 IndexM=-1 IndexN=0 KC2=385531421917553 PropagationState=Undefined Attenuation=1.7054704e+08 PolarizationState=TE AffectsRefinement} Mode{ModeNumber=4 IndexM=0 IndexN=-1 KC2=385531421917553 PropagationState=Undefined Attenuation=1.7054704e+08 PolarizationState=TE AffectsRefinement}}
  FloquetBaixo: Floquet Port Faces=Air_Domain.face(-z) NumModes=4 Modes{Mode1{CharImp=Zpi} Mode2{CharImp=Zpi} Mode3{CharImp=Zpi} Mode4{CharImp=Zpi}} PhaseDelay=UseScanAngle Phi=0deg Theta=theta_inc LatticeAVector{(-0.16, -0.16, -1) -> (0.16, -0.16, -1)} LatticeBVector{(-0.16, -0.16, -1) -> (-0.16, 0.16, -1)} ModesCalculator{Frequency=1GHz PhiStart=0deg PhiStop=0deg PhiStep=0deg ThetaStart=0deg ThetaStop=0deg ThetaStep=0deg} ModesList{Mode{ModeNumber=1 IndexM=0 IndexN=0 KC2=0 PropagationState=Undefined Attenuation=0 PolarizationState=TE AffectsRefinement} Mode{ModeNumber=2 IndexM=0 IndexN=0 KC2=0 PropagationState=Undefined Attenuation=0 PolarizationState=TM AffectsRefinement} Mode{ModeNumber=3 IndexM=-1 IndexN=0 KC2=385531421917553 PropagationState=Undefined Attenuation=1.7054704e+08 PolarizationState=TE AffectsRefinement} Mode{ModeNumber=4 IndexM=0 IndexN=-1 KC2=385531421917553 PropagationState=Undefined Attenuation=1.7054704e+08 PolarizationState=TE AffectsRefinement}}
setups:
  Setup1: HfssDriven Frequency=666.2THz MaxDeltaS=0.01 MaximumPasses=15 MinimumPasses=1 MinimumConvergedPasses=1 PercentRefinement=30 BasisOrder=1 PortAccuracy=2 DrivenSolverType="Direct Solver"
    sweep Varredura: 187.4THz to 666.2THz, 401 points; Type=Interpolating InterpTolerance=0.5 InterpMaxSolns=250 PassivityErrorTolerance=0.0001
source amplitudes:
  FloquetCima:1: 1W 0deg
  FloquetCima:2, FloquetCima:3, FloquetCima:4, FloquetBaixo:1..FloquetBaixo:4: 0W 0deg

design G0643_anelQ_anelC_trilhas (HFSS, HFSS Modal Network, model units um)
variables:
  theta_inc = 0deg
geometry:
  Au_anelq [Au_JC] = box(corner=(-0.0995um, -0.0995um, 0um), size=(0.199um, 0.199um, 0.03um))
  Au_anelq_furo = box(corner=(-0.0715um, -0.0715um, 0um), size=(0.143um, 0.143um, 0.03um))
  Au_anelq.subtract(Au_anelq_furo)
  Au_anelc = cylinder(axis=Z, base_centre=(0um, 0um, 0um), radius=0.052um, height=0.03um)
  Au_anelc_furo = cylinder(axis=Z, base_centre=(0um, 0um, 0um), radius=0.019um, height=0.03um)
  Au_anelc.subtract(Au_anelc_furo)
  Au_trilha0 = box(corner=(0.009um, -0.0105um, 0um), size=(0.0765um, 0.021um, 0.03um))
  Au_trilha1 = box(corner=(-0.0855um, -0.0105um, 0um), size=(0.0765um, 0.021um, 0.03um))
  Au_trilha2 = box(corner=(-0.0105um, 0.009um, 0um), size=(0.021um, 0.0765um, 0.03um))
  Au_trilha3 = box(corner=(-0.0105um, -0.0855um, 0um), size=(0.021um, 0.0765um, 0.03um))
  Au_anelq.unite(Au_anelc, Au_trilha0..Au_trilha3)
  Air_Domain [vacuum] = box(corner=(-0.16um, -0.16um, -1um), size=(0.32um, 0.32um, 2.03um))
  Au_anelq_1 = Au_anelq.copy()
  Air_Domain.subtract(Au_anelq_1)
boundaries and excitations:
  LatticePair_DBO1RU: Lattice Pair Faces=Air_Domain.face(-x, +x) CoordSysVector{(-0.16, -0.16, -1) -> (-0.16, -0.16, 1.03)} PhaseDelay=UseScanAngle Phi=0deg Theta=theta_inc
  LatticePair_6CYJWF: Lattice Pair Faces=Air_Domain.face(-y, +y) CoordSysVector{(0.16, -0.16, -1) -> (0.16, -0.16, 1.03)} PhaseDelay=UseScanAngle Phi=0deg Theta=theta_inc
  FloquetCima: Floquet Port Faces=Air_Domain.face(+z) NumModes=4 Modes{Mode1{CharImp=Zpi} Mode2{CharImp=Zpi} Mode3{CharImp=Zpi} Mode4{CharImp=Zpi}} PhaseDelay=UseScanAngle Phi=0deg Theta=theta_inc LatticeAVector{(-0.16, -0.16, 1.03) -> (0.16, -0.16, 1.03)} LatticeBVector{(-0.16, -0.16, 1.03) -> (-0.16, 0.16, 1.03)} ModesCalculator{Frequency=1GHz PhiStart=0deg PhiStop=0deg PhiStep=0deg ThetaStart=0deg ThetaStop=0deg ThetaStep=0deg} ModesList{Mode{ModeNumber=1 IndexM=0 IndexN=0 KC2=0 PropagationState=Undefined Attenuation=0 PolarizationState=TE AffectsRefinement} Mode{ModeNumber=2 IndexM=0 IndexN=0 KC2=0 PropagationState=Undefined Attenuation=0 PolarizationState=TM AffectsRefinement} Mode{ModeNumber=3 IndexM=-1 IndexN=0 KC2=385531421917553 PropagationState=Undefined Attenuation=1.7054704e+08 PolarizationState=TE AffectsRefinement} Mode{ModeNumber=4 IndexM=0 IndexN=-1 KC2=385531421917553 PropagationState=Undefined Attenuation=1.7054704e+08 PolarizationState=TE AffectsRefinement}}
  FloquetBaixo: Floquet Port Faces=Air_Domain.face(-z) NumModes=4 Modes{Mode1{CharImp=Zpi} Mode2{CharImp=Zpi} Mode3{CharImp=Zpi} Mode4{CharImp=Zpi}} PhaseDelay=UseScanAngle Phi=0deg Theta=theta_inc LatticeAVector{(-0.16, -0.16, -1) -> (0.16, -0.16, -1)} LatticeBVector{(-0.16, -0.16, -1) -> (-0.16, 0.16, -1)} ModesCalculator{Frequency=1GHz PhiStart=0deg PhiStop=0deg PhiStep=0deg ThetaStart=0deg ThetaStop=0deg ThetaStep=0deg} ModesList{Mode{ModeNumber=1 IndexM=0 IndexN=0 KC2=0 PropagationState=Undefined Attenuation=0 PolarizationState=TE AffectsRefinement} Mode{ModeNumber=2 IndexM=0 IndexN=0 KC2=0 PropagationState=Undefined Attenuation=0 PolarizationState=TM AffectsRefinement} Mode{ModeNumber=3 IndexM=-1 IndexN=0 KC2=385531421917553 PropagationState=Undefined Attenuation=1.7054704e+08 PolarizationState=TE AffectsRefinement} Mode{ModeNumber=4 IndexM=0 IndexN=-1 KC2=385531421917553 PropagationState=Undefined Attenuation=1.7054704e+08 PolarizationState=TE AffectsRefinement}}
setups:
  Setup1: HfssDriven Frequency=666.2THz MaxDeltaS=0.01 MaximumPasses=15 MinimumPasses=1 MinimumConvergedPasses=1 PercentRefinement=30 BasisOrder=1 PortAccuracy=2 DrivenSolverType="Direct Solver"
    sweep Varredura: 187.4THz to 666.2THz, 401 points; Type=Interpolating InterpTolerance=0.5 InterpMaxSolns=250 PassivityErrorTolerance=0.0001
source amplitudes:
  FloquetCima:1: 1W 0deg
  FloquetCima:2, FloquetCima:3, FloquetCima:4, FloquetBaixo:1..FloquetBaixo:4: 0W 0deg

design G0763_anelQ_anelC_trilhas (HFSS, HFSS Modal Network, model units um)
variables:
  theta_inc = 0deg
geometry:
  Au_anelq [Au_JC] = box(corner=(-0.0915um, -0.0915um, 0um), size=(0.183um, 0.183um, 0.03um))
  Au_anelq_furo = box(corner=(-0.0495um, -0.0495um, 0um), size=(0.099um, 0.099um, 0.03um))
  Au_anelq.subtract(Au_anelq_furo)
  Au_anelc = cylinder(axis=Z, base_centre=(0um, 0um, 0um), radius=0.037um, height=0.03um)
  Au_anelc_furo = cylinder(axis=Z, base_centre=(0um, 0um, 0um), radius=0.019um, height=0.03um)
  Au_anelc.subtract(Au_anelc_furo)
  Au_trilha0 = box(corner=(0.009um, -0.0095um, 0um), size=(0.0615um, 0.019um, 0.03um))
  Au_trilha1 = box(corner=(-0.0705um, -0.0095um, 0um), size=(0.0615um, 0.019um, 0.03um))
  Au_trilha2 = box(corner=(-0.0095um, 0.009um, 0um), size=(0.019um, 0.0615um, 0.03um))
  Au_trilha3 = box(corner=(-0.0095um, -0.0705um, 0um), size=(0.019um, 0.0615um, 0.03um))
  Au_anelq.unite(Au_anelc, Au_trilha0..Au_trilha3)
  Air_Domain [vacuum] = box(corner=(-0.16um, -0.16um, -1um), size=(0.32um, 0.32um, 2.03um))
  Au_anelq_1 = Au_anelq.copy()
  Air_Domain.subtract(Au_anelq_1)
boundaries and excitations:
  LatticePair_W993UJ: Lattice Pair Faces=Air_Domain.face(-x, +x) CoordSysVector{(-0.16, -0.16, -1) -> (-0.16, -0.16, 1.03)} PhaseDelay=UseScanAngle Phi=0deg Theta=theta_inc
  LatticePair_RMCDC5: Lattice Pair Faces=Air_Domain.face(-y, +y) CoordSysVector{(0.16, -0.16, -1) -> (0.16, -0.16, 1.03)} PhaseDelay=UseScanAngle Phi=0deg Theta=theta_inc
  FloquetCima: Floquet Port Faces=Air_Domain.face(+z) NumModes=4 Modes{Mode1{CharImp=Zpi} Mode2{CharImp=Zpi} Mode3{CharImp=Zpi} Mode4{CharImp=Zpi}} PhaseDelay=UseScanAngle Phi=0deg Theta=theta_inc LatticeAVector{(-0.16, -0.16, 1.03) -> (0.16, -0.16, 1.03)} LatticeBVector{(-0.16, -0.16, 1.03) -> (-0.16, 0.16, 1.03)} ModesCalculator{Frequency=1GHz PhiStart=0deg PhiStop=0deg PhiStep=0deg ThetaStart=0deg ThetaStop=0deg ThetaStep=0deg} ModesList{Mode{ModeNumber=1 IndexM=0 IndexN=0 KC2=0 PropagationState=Undefined Attenuation=0 PolarizationState=TE AffectsRefinement} Mode{ModeNumber=2 IndexM=0 IndexN=0 KC2=0 PropagationState=Undefined Attenuation=0 PolarizationState=TM AffectsRefinement} Mode{ModeNumber=3 IndexM=-1 IndexN=0 KC2=385531421917553 PropagationState=Undefined Attenuation=1.7054704e+08 PolarizationState=TE AffectsRefinement} Mode{ModeNumber=4 IndexM=0 IndexN=-1 KC2=385531421917553 PropagationState=Undefined Attenuation=1.7054704e+08 PolarizationState=TE AffectsRefinement}}
  FloquetBaixo: Floquet Port Faces=Air_Domain.face(-z) NumModes=4 Modes{Mode1{CharImp=Zpi} Mode2{CharImp=Zpi} Mode3{CharImp=Zpi} Mode4{CharImp=Zpi}} PhaseDelay=UseScanAngle Phi=0deg Theta=theta_inc LatticeAVector{(-0.16, -0.16, -1) -> (0.16, -0.16, -1)} LatticeBVector{(-0.16, -0.16, -1) -> (-0.16, 0.16, -1)} ModesCalculator{Frequency=1GHz PhiStart=0deg PhiStop=0deg PhiStep=0deg ThetaStart=0deg ThetaStop=0deg ThetaStep=0deg} ModesList{Mode{ModeNumber=1 IndexM=0 IndexN=0 KC2=0 PropagationState=Undefined Attenuation=0 PolarizationState=TE AffectsRefinement} Mode{ModeNumber=2 IndexM=0 IndexN=0 KC2=0 PropagationState=Undefined Attenuation=0 PolarizationState=TM AffectsRefinement} Mode{ModeNumber=3 IndexM=-1 IndexN=0 KC2=385531421917553 PropagationState=Undefined Attenuation=1.7054704e+08 PolarizationState=TE AffectsRefinement} Mode{ModeNumber=4 IndexM=0 IndexN=-1 KC2=385531421917553 PropagationState=Undefined Attenuation=1.7054704e+08 PolarizationState=TE AffectsRefinement}}
setups:
  Setup1: HfssDriven Frequency=666.2THz MaxDeltaS=0.01 MaximumPasses=15 MinimumPasses=1 MinimumConvergedPasses=1 PercentRefinement=30 BasisOrder=1 PortAccuracy=2 DrivenSolverType="Direct Solver"
    sweep Varredura: 187.4THz to 666.2THz, 401 points; Type=Interpolating InterpTolerance=0.5 InterpMaxSolns=250 PassivityErrorTolerance=0.0001
source amplitudes:
  FloquetCima:1: 1W 0deg
  FloquetCima:2, FloquetCima:3, FloquetCima:4, FloquetBaixo:1..FloquetBaixo:4: 0W 0deg

design G0679_anelQ_anelC_trilhas (HFSS, HFSS Modal Network, model units um)
variables:
  theta_inc = 0deg
geometry:
  Au_anelq [Au_JC] = box(corner=(-0.1185um, -0.1185um, 0um), size=(0.237um, 0.237um, 0.03um))
  Au_anelq_furo = box(corner=(-0.0725um, -0.0725um, 0um), size=(0.145um, 0.145um, 0.03um))
  Au_anelq.subtract(Au_anelq_furo)
  Au_anelc = cylinder(axis=Z, base_centre=(0um, 0um, 0um), radius=0.055um, height=0.03um)
  Au_anelc_furo = cylinder(axis=Z, base_centre=(0um, 0um, 0um), radius=0.021um, height=0.03um)
  Au_anelc.subtract(Au_anelc_furo)
  Au_trilha0 = box(corner=(0.011um, -0.0145um, 0um), size=(0.0845um, 0.029um, 0.03um))
  Au_trilha1 = box(corner=(-0.0955um, -0.0145um, 0um), size=(0.0845um, 0.029um, 0.03um))
  Au_trilha2 = box(corner=(-0.0145um, 0.011um, 0um), size=(0.029um, 0.0845um, 0.03um))
  Au_trilha3 = box(corner=(-0.0145um, -0.0955um, 0um), size=(0.029um, 0.0845um, 0.03um))
  Au_anelq.unite(Au_anelc, Au_trilha0..Au_trilha3)
  Air_Domain [vacuum] = box(corner=(-0.16um, -0.16um, -1um), size=(0.32um, 0.32um, 2.03um))
  Au_anelq_1 = Au_anelq.copy()
  Air_Domain.subtract(Au_anelq_1)
boundaries and excitations:
  LatticePair_G1KHT2: Lattice Pair Faces=Air_Domain.face(-x, +x) CoordSysVector{(-0.16, -0.16, -1) -> (-0.16, -0.16, 1.03)} PhaseDelay=UseScanAngle Phi=0deg Theta=theta_inc
  LatticePair_HJRN59: Lattice Pair Faces=Air_Domain.face(-y, +y) CoordSysVector{(0.16, -0.16, -1) -> (0.16, -0.16, 1.03)} PhaseDelay=UseScanAngle Phi=0deg Theta=theta_inc
  FloquetCima: Floquet Port Faces=Air_Domain.face(+z) NumModes=4 Modes{Mode1{CharImp=Zpi} Mode2{CharImp=Zpi} Mode3{CharImp=Zpi} Mode4{CharImp=Zpi}} PhaseDelay=UseScanAngle Phi=0deg Theta=theta_inc LatticeAVector{(-0.16, -0.16, 1.03) -> (0.16, -0.16, 1.03)} LatticeBVector{(-0.16, -0.16, 1.03) -> (-0.16, 0.16, 1.03)} ModesCalculator{Frequency=1GHz PhiStart=0deg PhiStop=0deg PhiStep=0deg ThetaStart=0deg ThetaStop=0deg ThetaStep=0deg} ModesList{Mode{ModeNumber=1 IndexM=0 IndexN=0 KC2=0 PropagationState=Undefined Attenuation=0 PolarizationState=TE AffectsRefinement} Mode{ModeNumber=2 IndexM=0 IndexN=0 KC2=0 PropagationState=Undefined Attenuation=0 PolarizationState=TM AffectsRefinement} Mode{ModeNumber=3 IndexM=-1 IndexN=0 KC2=385531421917553 PropagationState=Undefined Attenuation=1.7054704e+08 PolarizationState=TE AffectsRefinement} Mode{ModeNumber=4 IndexM=0 IndexN=-1 KC2=385531421917553 PropagationState=Undefined Attenuation=1.7054704e+08 PolarizationState=TE AffectsRefinement}}
  FloquetBaixo: Floquet Port Faces=Air_Domain.face(-z) NumModes=4 Modes{Mode1{CharImp=Zpi} Mode2{CharImp=Zpi} Mode3{CharImp=Zpi} Mode4{CharImp=Zpi}} PhaseDelay=UseScanAngle Phi=0deg Theta=theta_inc LatticeAVector{(-0.16, -0.16, -1) -> (0.16, -0.16, -1)} LatticeBVector{(-0.16, -0.16, -1) -> (-0.16, 0.16, -1)} ModesCalculator{Frequency=1GHz PhiStart=0deg PhiStop=0deg PhiStep=0deg ThetaStart=0deg ThetaStop=0deg ThetaStep=0deg} ModesList{Mode{ModeNumber=1 IndexM=0 IndexN=0 KC2=0 PropagationState=Undefined Attenuation=0 PolarizationState=TE AffectsRefinement} Mode{ModeNumber=2 IndexM=0 IndexN=0 KC2=0 PropagationState=Undefined Attenuation=0 PolarizationState=TM AffectsRefinement} Mode{ModeNumber=3 IndexM=-1 IndexN=0 KC2=385531421917553 PropagationState=Undefined Attenuation=1.7054704e+08 PolarizationState=TE AffectsRefinement} Mode{ModeNumber=4 IndexM=0 IndexN=-1 KC2=385531421917553 PropagationState=Undefined Attenuation=1.7054704e+08 PolarizationState=TE AffectsRefinement}}
setups:
  Setup1: HfssDriven Frequency=666.2THz MaxDeltaS=0.01 MaximumPasses=15 MinimumPasses=1 MinimumConvergedPasses=1 PercentRefinement=30 BasisOrder=1 PortAccuracy=2 DrivenSolverType="Direct Solver"
    sweep Varredura: 187.4THz to 666.2THz, 401 points; Type=Interpolating InterpTolerance=0.5 InterpMaxSolns=250 PassivityErrorTolerance=0.0001
source amplitudes:
  FloquetCima:1: 1W 0deg
  FloquetCima:2, FloquetCima:3, FloquetCima:4, FloquetBaixo:1..FloquetBaixo:4: 0W 0deg

design G0766_anelQ_anelC_trilhas (HFSS, HFSS Modal Network, model units um)
variables:
  theta_inc = 0deg
geometry:
  Au_anelq [Au_JC] = box(corner=(-0.1115um, -0.1115um, 0um), size=(0.223um, 0.223um, 0.03um))
  Au_anelq_furo = box(corner=(-0.0695um, -0.0695um, 0um), size=(0.139um, 0.139um, 0.03um))
  Au_anelq.subtract(Au_anelq_furo)
  Au_anelc = cylinder(axis=Z, base_centre=(0um, 0um, 0um), radius=0.055um, height=0.03um)
  Au_anelc_furo = cylinder(axis=Z, base_centre=(0um, 0um, 0um), radius=0.021um, height=0.03um)
  Au_anelc.subtract(Au_anelc_furo)
  Au_trilha0 = box(corner=(0.011um, -0.0075um, 0um), size=(0.0795um, 0.015um, 0.03um))
  Au_trilha1 = box(corner=(-0.0905um, -0.0075um, 0um), size=(0.0795um, 0.015um, 0.03um))
  Au_trilha2 = box(corner=(-0.0075um, 0.011um, 0um), size=(0.015um, 0.0795um, 0.03um))
  Au_trilha3 = box(corner=(-0.0075um, -0.0905um, 0um), size=(0.015um, 0.0795um, 0.03um))
  Au_anelq.unite(Au_anelc, Au_trilha0..Au_trilha3)
  Air_Domain [vacuum] = box(corner=(-0.16um, -0.16um, -1um), size=(0.32um, 0.32um, 2.03um))
  Au_anelq_1 = Au_anelq.copy()
  Air_Domain.subtract(Au_anelq_1)
boundaries and excitations:
  LatticePair_Z0PLV7: Lattice Pair Faces=Air_Domain.face(-x, +x) CoordSysVector{(-0.16, -0.16, -1) -> (-0.16, -0.16, 1.03)} PhaseDelay=UseScanAngle Phi=0deg Theta=theta_inc
  LatticePair_DIG1OR: Lattice Pair Faces=Air_Domain.face(-y, +y) CoordSysVector{(0.16, -0.16, -1) -> (0.16, -0.16, 1.03)} PhaseDelay=UseScanAngle Phi=0deg Theta=theta_inc
  FloquetCima: Floquet Port Faces=Air_Domain.face(+z) NumModes=4 Modes{Mode1{CharImp=Zpi} Mode2{CharImp=Zpi} Mode3{CharImp=Zpi} Mode4{CharImp=Zpi}} PhaseDelay=UseScanAngle Phi=0deg Theta=theta_inc LatticeAVector{(-0.16, -0.16, 1.03) -> (0.16, -0.16, 1.03)} LatticeBVector{(-0.16, -0.16, 1.03) -> (-0.16, 0.16, 1.03)} ModesCalculator{Frequency=1GHz PhiStart=0deg PhiStop=0deg PhiStep=0deg ThetaStart=0deg ThetaStop=0deg ThetaStep=0deg} ModesList{Mode{ModeNumber=1 IndexM=0 IndexN=0 KC2=0 PropagationState=Undefined Attenuation=0 PolarizationState=TE AffectsRefinement} Mode{ModeNumber=2 IndexM=0 IndexN=0 KC2=0 PropagationState=Undefined Attenuation=0 PolarizationState=TM AffectsRefinement} Mode{ModeNumber=3 IndexM=-1 IndexN=0 KC2=385531421917553 PropagationState=Undefined Attenuation=1.7054704e+08 PolarizationState=TE AffectsRefinement} Mode{ModeNumber=4 IndexM=0 IndexN=-1 KC2=385531421917553 PropagationState=Undefined Attenuation=1.7054704e+08 PolarizationState=TE AffectsRefinement}}
  FloquetBaixo: Floquet Port Faces=Air_Domain.face(-z) NumModes=4 Modes{Mode1{CharImp=Zpi} Mode2{CharImp=Zpi} Mode3{CharImp=Zpi} Mode4{CharImp=Zpi}} PhaseDelay=UseScanAngle Phi=0deg Theta=theta_inc LatticeAVector{(-0.16, -0.16, -1) -> (0.16, -0.16, -1)} LatticeBVector{(-0.16, -0.16, -1) -> (-0.16, 0.16, -1)} ModesCalculator{Frequency=1GHz PhiStart=0deg PhiStop=0deg PhiStep=0deg ThetaStart=0deg ThetaStop=0deg ThetaStep=0deg} ModesList{Mode{ModeNumber=1 IndexM=0 IndexN=0 KC2=0 PropagationState=Undefined Attenuation=0 PolarizationState=TE AffectsRefinement} Mode{ModeNumber=2 IndexM=0 IndexN=0 KC2=0 PropagationState=Undefined Attenuation=0 PolarizationState=TM AffectsRefinement} Mode{ModeNumber=3 IndexM=-1 IndexN=0 KC2=385531421917553 PropagationState=Undefined Attenuation=1.7054704e+08 PolarizationState=TE AffectsRefinement} Mode{ModeNumber=4 IndexM=0 IndexN=-1 KC2=385531421917553 PropagationState=Undefined Attenuation=1.7054704e+08 PolarizationState=TE AffectsRefinement}}
setups:
  Setup1: HfssDriven Frequency=666.2THz MaxDeltaS=0.01 MaximumPasses=15 MinimumPasses=1 MinimumConvergedPasses=1 PercentRefinement=30 BasisOrder=1 PortAccuracy=2 DrivenSolverType="Direct Solver"
    sweep Varredura: 187.4THz to 666.2THz, 401 points; Type=Interpolating InterpTolerance=0.5 InterpMaxSolns=250 PassivityErrorTolerance=0.0001
source amplitudes:
  FloquetCima:1: 1W 0deg
  FloquetCima:2, FloquetCima:3, FloquetCima:4, FloquetBaixo:1..FloquetBaixo:4: 0W 0deg

design G0934_anelQ_disco (HFSS, HFSS Modal Network, model units um)
variables:
  theta_inc = 0deg
geometry:
  Au_anelq [Au_JC] = box(corner=(-0.109um, -0.109um, 0um), size=(0.218um, 0.218um, 0.03um))
  Au_anelq_furo = box(corner=(-0.072um, -0.072um, 0um), size=(0.144um, 0.144um, 0.03um))
  Au_anelq.subtract(Au_anelq_furo)
  Au_disco = cylinder(axis=Z, base_centre=(0um, 0um, 0um), radius=0.024um, height=0.03um)
  Au_anelq.unite(Au_disco)
  Air_Domain [vacuum] = box(corner=(-0.16um, -0.16um, -1um), size=(0.32um, 0.32um, 2.03um))
  Au_anelq_1 = Au_anelq.copy()
  Air_Domain.subtract(Au_anelq_1)
boundaries and excitations:
  LatticePair_S608CB: Lattice Pair Faces=Air_Domain.face(-x, +x) CoordSysVector{(-0.16, -0.16, -1) -> (-0.16, -0.16, 1.03)} PhaseDelay=UseScanAngle Phi=0deg Theta=theta_inc
  LatticePair_TYDDXL: Lattice Pair Faces=Air_Domain.face(-y, +y) CoordSysVector{(0.16, -0.16, -1) -> (0.16, -0.16, 1.03)} PhaseDelay=UseScanAngle Phi=0deg Theta=theta_inc
  FloquetCima: Floquet Port Faces=Air_Domain.face(+z) NumModes=4 Modes{Mode1{CharImp=Zpi} Mode2{CharImp=Zpi} Mode3{CharImp=Zpi} Mode4{CharImp=Zpi}} PhaseDelay=UseScanAngle Phi=0deg Theta=theta_inc LatticeAVector{(-0.16, -0.16, 1.03) -> (0.16, -0.16, 1.03)} LatticeBVector{(-0.16, -0.16, 1.03) -> (-0.16, 0.16, 1.03)} ModesCalculator{Frequency=1GHz PhiStart=0deg PhiStop=0deg PhiStep=0deg ThetaStart=0deg ThetaStop=0deg ThetaStep=0deg} ModesList{Mode{ModeNumber=1 IndexM=0 IndexN=0 KC2=0 PropagationState=Undefined Attenuation=0 PolarizationState=TE AffectsRefinement} Mode{ModeNumber=2 IndexM=0 IndexN=0 KC2=0 PropagationState=Undefined Attenuation=0 PolarizationState=TM AffectsRefinement} Mode{ModeNumber=3 IndexM=-1 IndexN=0 KC2=385531421917553 PropagationState=Undefined Attenuation=1.7054704e+08 PolarizationState=TE AffectsRefinement} Mode{ModeNumber=4 IndexM=0 IndexN=-1 KC2=385531421917553 PropagationState=Undefined Attenuation=1.7054704e+08 PolarizationState=TE AffectsRefinement}}
  FloquetBaixo: Floquet Port Faces=Air_Domain.face(-z) NumModes=4 Modes{Mode1{CharImp=Zpi} Mode2{CharImp=Zpi} Mode3{CharImp=Zpi} Mode4{CharImp=Zpi}} PhaseDelay=UseScanAngle Phi=0deg Theta=theta_inc LatticeAVector{(-0.16, -0.16, -1) -> (0.16, -0.16, -1)} LatticeBVector{(-0.16, -0.16, -1) -> (-0.16, 0.16, -1)} ModesCalculator{Frequency=1GHz PhiStart=0deg PhiStop=0deg PhiStep=0deg ThetaStart=0deg ThetaStop=0deg ThetaStep=0deg} ModesList{Mode{ModeNumber=1 IndexM=0 IndexN=0 KC2=0 PropagationState=Undefined Attenuation=0 PolarizationState=TE AffectsRefinement} Mode{ModeNumber=2 IndexM=0 IndexN=0 KC2=0 PropagationState=Undefined Attenuation=0 PolarizationState=TM AffectsRefinement} Mode{ModeNumber=3 IndexM=-1 IndexN=0 KC2=385531421917553 PropagationState=Undefined Attenuation=1.7054704e+08 PolarizationState=TE AffectsRefinement} Mode{ModeNumber=4 IndexM=0 IndexN=-1 KC2=385531421917553 PropagationState=Undefined Attenuation=1.7054704e+08 PolarizationState=TE AffectsRefinement}}
setups:
  Setup1: HfssDriven Frequency=666.2THz MaxDeltaS=0.01 MaximumPasses=15 MinimumPasses=1 MinimumConvergedPasses=1 PercentRefinement=30 BasisOrder=1 PortAccuracy=2 DrivenSolverType="Direct Solver"
    sweep Varredura: 187.4THz to 666.2THz, 401 points; Type=Interpolating InterpTolerance=0.5 InterpMaxSolns=250 PassivityErrorTolerance=0.0001
source amplitudes:
  FloquetCima:1: 1W 0deg
  FloquetCima:2, FloquetCima:3, FloquetCima:4, FloquetBaixo:1..FloquetBaixo:4: 0W 0deg

design G0981_anelQ_disco (HFSS, HFSS Modal Network, model units um)
variables:
  theta_inc = 0deg
geometry:
  Au_anelq [Au_JC] = box(corner=(-0.0965um, -0.0965um, 0um), size=(0.193um, 0.193um, 0.03um))
  Au_anelq_furo = box(corner=(-0.0515um, -0.0515um, 0um), size=(0.103um, 0.103um, 0.03um))
  Au_anelq.subtract(Au_anelq_furo)
  Au_disco = cylinder(axis=Z, base_centre=(0um, 0um, 0um), radius=0.027um, height=0.03um)
  Au_anelq.unite(Au_disco)
  Air_Domain [vacuum] = box(corner=(-0.16um, -0.16um, -1um), size=(0.32um, 0.32um, 2.03um))
  Au_anelq_1 = Au_anelq.copy()
  Air_Domain.subtract(Au_anelq_1)
boundaries and excitations:
  LatticePair_92YHN3: Lattice Pair Faces=Air_Domain.face(-x, +x) CoordSysVector{(-0.16, -0.16, -1) -> (-0.16, -0.16, 1.03)} PhaseDelay=UseScanAngle Phi=0deg Theta=theta_inc
  LatticePair_WT1O1G: Lattice Pair Faces=Air_Domain.face(-y, +y) CoordSysVector{(0.16, -0.16, -1) -> (0.16, -0.16, 1.03)} PhaseDelay=UseScanAngle Phi=0deg Theta=theta_inc
  FloquetCima: Floquet Port Faces=Air_Domain.face(+z) NumModes=4 Modes{Mode1{CharImp=Zpi} Mode2{CharImp=Zpi} Mode3{CharImp=Zpi} Mode4{CharImp=Zpi}} PhaseDelay=UseScanAngle Phi=0deg Theta=theta_inc LatticeAVector{(-0.16, -0.16, 1.03) -> (0.16, -0.16, 1.03)} LatticeBVector{(-0.16, -0.16, 1.03) -> (-0.16, 0.16, 1.03)} ModesCalculator{Frequency=1GHz PhiStart=0deg PhiStop=0deg PhiStep=0deg ThetaStart=0deg ThetaStop=0deg ThetaStep=0deg} ModesList{Mode{ModeNumber=1 IndexM=0 IndexN=0 KC2=0 PropagationState=Undefined Attenuation=0 PolarizationState=TE AffectsRefinement} Mode{ModeNumber=2 IndexM=0 IndexN=0 KC2=0 PropagationState=Undefined Attenuation=0 PolarizationState=TM AffectsRefinement} Mode{ModeNumber=3 IndexM=-1 IndexN=0 KC2=385531421917553 PropagationState=Undefined Attenuation=1.7054704e+08 PolarizationState=TE AffectsRefinement} Mode{ModeNumber=4 IndexM=0 IndexN=-1 KC2=385531421917553 PropagationState=Undefined Attenuation=1.7054704e+08 PolarizationState=TE AffectsRefinement}}
  FloquetBaixo: Floquet Port Faces=Air_Domain.face(-z) NumModes=4 Modes{Mode1{CharImp=Zpi} Mode2{CharImp=Zpi} Mode3{CharImp=Zpi} Mode4{CharImp=Zpi}} PhaseDelay=UseScanAngle Phi=0deg Theta=theta_inc LatticeAVector{(-0.16, -0.16, -1) -> (0.16, -0.16, -1)} LatticeBVector{(-0.16, -0.16, -1) -> (-0.16, 0.16, -1)} ModesCalculator{Frequency=1GHz PhiStart=0deg PhiStop=0deg PhiStep=0deg ThetaStart=0deg ThetaStop=0deg ThetaStep=0deg} ModesList{Mode{ModeNumber=1 IndexM=0 IndexN=0 KC2=0 PropagationState=Undefined Attenuation=0 PolarizationState=TE AffectsRefinement} Mode{ModeNumber=2 IndexM=0 IndexN=0 KC2=0 PropagationState=Undefined Attenuation=0 PolarizationState=TM AffectsRefinement} Mode{ModeNumber=3 IndexM=-1 IndexN=0 KC2=385531421917553 PropagationState=Undefined Attenuation=1.7054704e+08 PolarizationState=TE AffectsRefinement} Mode{ModeNumber=4 IndexM=0 IndexN=-1 KC2=385531421917553 PropagationState=Undefined Attenuation=1.7054704e+08 PolarizationState=TE AffectsRefinement}}
setups:
  Setup1: HfssDriven Frequency=666.2THz MaxDeltaS=0.01 MaximumPasses=15 MinimumPasses=1 MinimumConvergedPasses=1 PercentRefinement=30 BasisOrder=1 PortAccuracy=2 DrivenSolverType="Direct Solver"
    sweep Varredura: 187.4THz to 666.2THz, 401 points; Type=Interpolating InterpTolerance=0.5 InterpMaxSolns=250 PassivityErrorTolerance=0.0001
source amplitudes:
  FloquetCima:1: 1W 0deg
  FloquetCima:2, FloquetCima:3, FloquetCima:4, FloquetBaixo:1..FloquetBaixo:4: 0W 0deg

design G0884_anelQ_disco (HFSS, HFSS Modal Network, model units um)
variables:
  theta_inc = 0deg
geometry:
  Au_anelq [Au_JC] = box(corner=(-0.1035um, -0.1035um, 0um), size=(0.207um, 0.207um, 0.03um))
  Au_anelq_furo = box(corner=(-0.0555um, -0.0555um, 0um), size=(0.111um, 0.111um, 0.03um))
  Au_anelq.subtract(Au_anelq_furo)
  Au_disco = cylinder(axis=Z, base_centre=(0um, 0um, 0um), radius=0.022um, height=0.03um)
  Au_anelq.unite(Au_disco)
  Air_Domain [vacuum] = box(corner=(-0.16um, -0.16um, -1um), size=(0.32um, 0.32um, 2.03um))
  Au_anelq_1 = Au_anelq.copy()
  Air_Domain.subtract(Au_anelq_1)
boundaries and excitations:
  LatticePair_9A7H6A: Lattice Pair Faces=Air_Domain.face(-x, +x) CoordSysVector{(-0.16, -0.16, -1) -> (-0.16, -0.16, 1.03)} PhaseDelay=UseScanAngle Phi=0deg Theta=theta_inc
  LatticePair_N0JKF2: Lattice Pair Faces=Air_Domain.face(-y, +y) CoordSysVector{(0.16, -0.16, -1) -> (0.16, -0.16, 1.03)} PhaseDelay=UseScanAngle Phi=0deg Theta=theta_inc
  FloquetCima: Floquet Port Faces=Air_Domain.face(+z) NumModes=4 Modes{Mode1{CharImp=Zpi} Mode2{CharImp=Zpi} Mode3{CharImp=Zpi} Mode4{CharImp=Zpi}} PhaseDelay=UseScanAngle Phi=0deg Theta=theta_inc LatticeAVector{(-0.16, -0.16, 1.03) -> (0.16, -0.16, 1.03)} LatticeBVector{(-0.16, -0.16, 1.03) -> (-0.16, 0.16, 1.03)} ModesCalculator{Frequency=1GHz PhiStart=0deg PhiStop=0deg PhiStep=0deg ThetaStart=0deg ThetaStop=0deg ThetaStep=0deg} ModesList{Mode{ModeNumber=1 IndexM=0 IndexN=0 KC2=0 PropagationState=Undefined Attenuation=0 PolarizationState=TE AffectsRefinement} Mode{ModeNumber=2 IndexM=0 IndexN=0 KC2=0 PropagationState=Undefined Attenuation=0 PolarizationState=TM AffectsRefinement} Mode{ModeNumber=3 IndexM=-1 IndexN=0 KC2=385531421917553 PropagationState=Undefined Attenuation=1.7054704e+08 PolarizationState=TE AffectsRefinement} Mode{ModeNumber=4 IndexM=0 IndexN=-1 KC2=385531421917553 PropagationState=Undefined Attenuation=1.7054704e+08 PolarizationState=TE AffectsRefinement}}
  FloquetBaixo: Floquet Port Faces=Air_Domain.face(-z) NumModes=4 Modes{Mode1{CharImp=Zpi} Mode2{CharImp=Zpi} Mode3{CharImp=Zpi} Mode4{CharImp=Zpi}} PhaseDelay=UseScanAngle Phi=0deg Theta=theta_inc LatticeAVector{(-0.16, -0.16, -1) -> (0.16, -0.16, -1)} LatticeBVector{(-0.16, -0.16, -1) -> (-0.16, 0.16, -1)} ModesCalculator{Frequency=1GHz PhiStart=0deg PhiStop=0deg PhiStep=0deg ThetaStart=0deg ThetaStop=0deg ThetaStep=0deg} ModesList{Mode{ModeNumber=1 IndexM=0 IndexN=0 KC2=0 PropagationState=Undefined Attenuation=0 PolarizationState=TE AffectsRefinement} Mode{ModeNumber=2 IndexM=0 IndexN=0 KC2=0 PropagationState=Undefined Attenuation=0 PolarizationState=TM AffectsRefinement} Mode{ModeNumber=3 IndexM=-1 IndexN=0 KC2=385531421917553 PropagationState=Undefined Attenuation=1.7054704e+08 PolarizationState=TE AffectsRefinement} Mode{ModeNumber=4 IndexM=0 IndexN=-1 KC2=385531421917553 PropagationState=Undefined Attenuation=1.7054704e+08 PolarizationState=TE AffectsRefinement}}
setups:
  Setup1: HfssDriven Frequency=666.2THz MaxDeltaS=0.01 MaximumPasses=15 MinimumPasses=1 MinimumConvergedPasses=1 PercentRefinement=30 BasisOrder=1 PortAccuracy=2 DrivenSolverType="Direct Solver"
    sweep Varredura: 187.4THz to 666.2THz, 401 points; Type=Interpolating InterpTolerance=0.5 InterpMaxSolns=250 PassivityErrorTolerance=0.0001
source amplitudes:
  FloquetCima:1: 1W 0deg
  FloquetCima:2, FloquetCima:3, FloquetCima:4, FloquetBaixo:1..FloquetBaixo:4: 0W 0deg

design G0941_anelQ_disco (HFSS, HFSS Modal Network, model units um)
variables:
  theta_inc = 0deg
geometry:
  Au_anelq [Au_JC] = box(corner=(-0.1185um, -0.1185um, 0um), size=(0.237um, 0.237um, 0.03um))
  Au_anelq_furo = box(corner=(-0.0755um, -0.0755um, 0um), size=(0.151um, 0.151um, 0.03um))
  Au_anelq.subtract(Au_anelq_furo)
  Au_disco = cylinder(axis=Z, base_centre=(0um, 0um, 0um), radius=0.026um, height=0.03um)
  Au_anelq.unite(Au_disco)
  Air_Domain [vacuum] = box(corner=(-0.16um, -0.16um, -1um), size=(0.32um, 0.32um, 2.03um))
  Au_anelq_1 = Au_anelq.copy()
  Air_Domain.subtract(Au_anelq_1)
boundaries and excitations:
  LatticePair_5QAU8M: Lattice Pair Faces=Air_Domain.face(-x, +x) CoordSysVector{(-0.16, -0.16, -1) -> (-0.16, -0.16, 1.03)} PhaseDelay=UseScanAngle Phi=0deg Theta=theta_inc
  LatticePair_YS2YLN: Lattice Pair Faces=Air_Domain.face(-y, +y) CoordSysVector{(0.16, -0.16, -1) -> (0.16, -0.16, 1.03)} PhaseDelay=UseScanAngle Phi=0deg Theta=theta_inc
  FloquetCima: Floquet Port Faces=Air_Domain.face(+z) NumModes=4 Modes{Mode1{CharImp=Zpi} Mode2{CharImp=Zpi} Mode3{CharImp=Zpi} Mode4{CharImp=Zpi}} PhaseDelay=UseScanAngle Phi=0deg Theta=theta_inc LatticeAVector{(-0.16, -0.16, 1.03) -> (0.16, -0.16, 1.03)} LatticeBVector{(-0.16, -0.16, 1.03) -> (-0.16, 0.16, 1.03)} ModesCalculator{Frequency=1GHz PhiStart=0deg PhiStop=0deg PhiStep=0deg ThetaStart=0deg ThetaStop=0deg ThetaStep=0deg} ModesList{Mode{ModeNumber=1 IndexM=0 IndexN=0 KC2=0 PropagationState=Undefined Attenuation=0 PolarizationState=TE AffectsRefinement} Mode{ModeNumber=2 IndexM=0 IndexN=0 KC2=0 PropagationState=Undefined Attenuation=0 PolarizationState=TM AffectsRefinement} Mode{ModeNumber=3 IndexM=-1 IndexN=0 KC2=385531421917553 PropagationState=Undefined Attenuation=1.7054704e+08 PolarizationState=TE AffectsRefinement} Mode{ModeNumber=4 IndexM=0 IndexN=-1 KC2=385531421917553 PropagationState=Undefined Attenuation=1.7054704e+08 PolarizationState=TE AffectsRefinement}}
  FloquetBaixo: Floquet Port Faces=Air_Domain.face(-z) NumModes=4 Modes{Mode1{CharImp=Zpi} Mode2{CharImp=Zpi} Mode3{CharImp=Zpi} Mode4{CharImp=Zpi}} PhaseDelay=UseScanAngle Phi=0deg Theta=theta_inc LatticeAVector{(-0.16, -0.16, -1) -> (0.16, -0.16, -1)} LatticeBVector{(-0.16, -0.16, -1) -> (-0.16, 0.16, -1)} ModesCalculator{Frequency=1GHz PhiStart=0deg PhiStop=0deg PhiStep=0deg ThetaStart=0deg ThetaStop=0deg ThetaStep=0deg} ModesList{Mode{ModeNumber=1 IndexM=0 IndexN=0 KC2=0 PropagationState=Undefined Attenuation=0 PolarizationState=TE AffectsRefinement} Mode{ModeNumber=2 IndexM=0 IndexN=0 KC2=0 PropagationState=Undefined Attenuation=0 PolarizationState=TM AffectsRefinement} Mode{ModeNumber=3 IndexM=-1 IndexN=0 KC2=385531421917553 PropagationState=Undefined Attenuation=1.7054704e+08 PolarizationState=TE AffectsRefinement} Mode{ModeNumber=4 IndexM=0 IndexN=-1 KC2=385531421917553 PropagationState=Undefined Attenuation=1.7054704e+08 PolarizationState=TE AffectsRefinement}}
setups:
  Setup1: HfssDriven Frequency=666.2THz MaxDeltaS=0.01 MaximumPasses=15 MinimumPasses=1 MinimumConvergedPasses=1 PercentRefinement=30 BasisOrder=1 PortAccuracy=2 DrivenSolverType="Direct Solver"
    sweep Varredura: 187.4THz to 666.2THz, 401 points; Type=Interpolating InterpTolerance=0.5 InterpMaxSolns=250 PassivityErrorTolerance=0.0001
source amplitudes:
  FloquetCima:1: 1W 0deg
  FloquetCima:2, FloquetCima:3, FloquetCima:4, FloquetBaixo:1..FloquetBaixo:4: 0W 0deg

design G0909_anelQ_disco (HFSS, HFSS Modal Network, model units um)
variables:
  theta_inc = 0deg
geometry:
  Au_anelq [Au_JC] = box(corner=(-0.082um, -0.082um, 0um), size=(0.164um, 0.164um, 0.03um))
  Au_anelq_furo = box(corner=(-0.048um, -0.048um, 0um), size=(0.096um, 0.096um, 0.03um))
  Au_anelq.subtract(Au_anelq_furo)
  Au_disco = cylinder(axis=Z, base_centre=(0um, 0um, 0um), radius=0.03um, height=0.03um)
  Au_anelq.unite(Au_disco)
  Air_Domain [vacuum] = box(corner=(-0.16um, -0.16um, -1um), size=(0.32um, 0.32um, 2.03um))
  Au_anelq_1 = Au_anelq.copy()
  Air_Domain.subtract(Au_anelq_1)
boundaries and excitations:
  LatticePair_83NZGA: Lattice Pair Faces=Air_Domain.face(-x, +x) CoordSysVector{(-0.16, -0.16, -1) -> (-0.16, -0.16, 1.03)} PhaseDelay=UseScanAngle Phi=0deg Theta=theta_inc
  LatticePair_JIP7V0: Lattice Pair Faces=Air_Domain.face(-y, +y) CoordSysVector{(0.16, -0.16, -1) -> (0.16, -0.16, 1.03)} PhaseDelay=UseScanAngle Phi=0deg Theta=theta_inc
  FloquetCima: Floquet Port Faces=Air_Domain.face(+z) NumModes=4 Modes{Mode1{CharImp=Zpi} Mode2{CharImp=Zpi} Mode3{CharImp=Zpi} Mode4{CharImp=Zpi}} PhaseDelay=UseScanAngle Phi=0deg Theta=theta_inc LatticeAVector{(-0.16, -0.16, 1.03) -> (0.16, -0.16, 1.03)} LatticeBVector{(-0.16, -0.16, 1.03) -> (-0.16, 0.16, 1.03)} ModesCalculator{Frequency=1GHz PhiStart=0deg PhiStop=0deg PhiStep=0deg ThetaStart=0deg ThetaStop=0deg ThetaStep=0deg} ModesList{Mode{ModeNumber=1 IndexM=0 IndexN=0 KC2=0 PropagationState=Undefined Attenuation=0 PolarizationState=TE AffectsRefinement} Mode{ModeNumber=2 IndexM=0 IndexN=0 KC2=0 PropagationState=Undefined Attenuation=0 PolarizationState=TM AffectsRefinement} Mode{ModeNumber=3 IndexM=-1 IndexN=0 KC2=385531421917553 PropagationState=Undefined Attenuation=1.7054704e+08 PolarizationState=TE AffectsRefinement} Mode{ModeNumber=4 IndexM=0 IndexN=-1 KC2=385531421917553 PropagationState=Undefined Attenuation=1.7054704e+08 PolarizationState=TE AffectsRefinement}}
  FloquetBaixo: Floquet Port Faces=Air_Domain.face(-z) NumModes=4 Modes{Mode1{CharImp=Zpi} Mode2{CharImp=Zpi} Mode3{CharImp=Zpi} Mode4{CharImp=Zpi}} PhaseDelay=UseScanAngle Phi=0deg Theta=theta_inc LatticeAVector{(-0.16, -0.16, -1) -> (0.16, -0.16, -1)} LatticeBVector{(-0.16, -0.16, -1) -> (-0.16, 0.16, -1)} ModesCalculator{Frequency=1GHz PhiStart=0deg PhiStop=0deg PhiStep=0deg ThetaStart=0deg ThetaStop=0deg ThetaStep=0deg} ModesList{Mode{ModeNumber=1 IndexM=0 IndexN=0 KC2=0 PropagationState=Undefined Attenuation=0 PolarizationState=TE AffectsRefinement} Mode{ModeNumber=2 IndexM=0 IndexN=0 KC2=0 PropagationState=Undefined Attenuation=0 PolarizationState=TM AffectsRefinement} Mode{ModeNumber=3 IndexM=-1 IndexN=0 KC2=385531421917553 PropagationState=Undefined Attenuation=1.7054704e+08 PolarizationState=TE AffectsRefinement} Mode{ModeNumber=4 IndexM=0 IndexN=-1 KC2=385531421917553 PropagationState=Undefined Attenuation=1.7054704e+08 PolarizationState=TE AffectsRefinement}}
setups:
  Setup1: HfssDriven Frequency=666.2THz MaxDeltaS=0.01 MaximumPasses=15 MinimumPasses=1 MinimumConvergedPasses=1 PercentRefinement=30 BasisOrder=1 PortAccuracy=2 DrivenSolverType="Direct Solver"
    sweep Varredura: 187.4THz to 666.2THz, 401 points; Type=Interpolating InterpTolerance=0.5 InterpMaxSolns=250 PassivityErrorTolerance=0.0001
source amplitudes:
  FloquetCima:1: 1W 0deg
  FloquetCima:2, FloquetCima:3, FloquetCima:4, FloquetBaixo:1..FloquetBaixo:4: 0W 0deg

design G0919_anelQ_disco (HFSS, HFSS Modal Network, model units um)
variables:
  theta_inc = 0deg
geometry:
  Au_anelq [Au_JC] = box(corner=(-0.107um, -0.107um, 0um), size=(0.214um, 0.214um, 0.03um))
  Au_anelq_furo = box(corner=(-0.07um, -0.07um, 0um), size=(0.14um, 0.14um, 0.03um))
  Au_anelq.subtract(Au_anelq_furo)
  Au_disco = cylinder(axis=Z, base_centre=(0um, 0um, 0um), radius=0.043um, height=0.03um)
  Au_anelq.unite(Au_disco)
  Air_Domain [vacuum] = box(corner=(-0.16um, -0.16um, -1um), size=(0.32um, 0.32um, 2.03um))
  Au_anelq_1 = Au_anelq.copy()
  Air_Domain.subtract(Au_anelq_1)
boundaries and excitations:
  LatticePair_TMO1MK: Lattice Pair Faces=Air_Domain.face(-x, +x) CoordSysVector{(-0.16, -0.16, -1) -> (-0.16, -0.16, 1.03)} PhaseDelay=UseScanAngle Phi=0deg Theta=theta_inc
  LatticePair_WSHGXT: Lattice Pair Faces=Air_Domain.face(-y, +y) CoordSysVector{(0.16, -0.16, -1) -> (0.16, -0.16, 1.03)} PhaseDelay=UseScanAngle Phi=0deg Theta=theta_inc
  FloquetCima: Floquet Port Faces=Air_Domain.face(+z) NumModes=4 Modes{Mode1{CharImp=Zpi} Mode2{CharImp=Zpi} Mode3{CharImp=Zpi} Mode4{CharImp=Zpi}} PhaseDelay=UseScanAngle Phi=0deg Theta=theta_inc LatticeAVector{(-0.16, -0.16, 1.03) -> (0.16, -0.16, 1.03)} LatticeBVector{(-0.16, -0.16, 1.03) -> (-0.16, 0.16, 1.03)} ModesCalculator{Frequency=1GHz PhiStart=0deg PhiStop=0deg PhiStep=0deg ThetaStart=0deg ThetaStop=0deg ThetaStep=0deg} ModesList{Mode{ModeNumber=1 IndexM=0 IndexN=0 KC2=0 PropagationState=Undefined Attenuation=0 PolarizationState=TE AffectsRefinement} Mode{ModeNumber=2 IndexM=0 IndexN=0 KC2=0 PropagationState=Undefined Attenuation=0 PolarizationState=TM AffectsRefinement} Mode{ModeNumber=3 IndexM=-1 IndexN=0 KC2=385531421917553 PropagationState=Undefined Attenuation=1.7054704e+08 PolarizationState=TE AffectsRefinement} Mode{ModeNumber=4 IndexM=0 IndexN=-1 KC2=385531421917553 PropagationState=Undefined Attenuation=1.7054704e+08 PolarizationState=TE AffectsRefinement}}
  FloquetBaixo: Floquet Port Faces=Air_Domain.face(-z) NumModes=4 Modes{Mode1{CharImp=Zpi} Mode2{CharImp=Zpi} Mode3{CharImp=Zpi} Mode4{CharImp=Zpi}} PhaseDelay=UseScanAngle Phi=0deg Theta=theta_inc LatticeAVector{(-0.16, -0.16, -1) -> (0.16, -0.16, -1)} LatticeBVector{(-0.16, -0.16, -1) -> (-0.16, 0.16, -1)} ModesCalculator{Frequency=1GHz PhiStart=0deg PhiStop=0deg PhiStep=0deg ThetaStart=0deg ThetaStop=0deg ThetaStep=0deg} ModesList{Mode{ModeNumber=1 IndexM=0 IndexN=0 KC2=0 PropagationState=Undefined Attenuation=0 PolarizationState=TE AffectsRefinement} Mode{ModeNumber=2 IndexM=0 IndexN=0 KC2=0 PropagationState=Undefined Attenuation=0 PolarizationState=TM AffectsRefinement} Mode{ModeNumber=3 IndexM=-1 IndexN=0 KC2=385531421917553 PropagationState=Undefined Attenuation=1.7054704e+08 PolarizationState=TE AffectsRefinement} Mode{ModeNumber=4 IndexM=0 IndexN=-1 KC2=385531421917553 PropagationState=Undefined Attenuation=1.7054704e+08 PolarizationState=TE AffectsRefinement}}
setups:
  Setup1: HfssDriven Frequency=666.2THz MaxDeltaS=0.01 MaximumPasses=15 MinimumPasses=1 MinimumConvergedPasses=1 PercentRefinement=30 BasisOrder=1 PortAccuracy=2 DrivenSolverType="Direct Solver"
    sweep Varredura: 187.4THz to 666.2THz, 401 points; Type=Interpolating InterpTolerance=0.5 InterpMaxSolns=250 PassivityErrorTolerance=0.0001
source amplitudes:
  FloquetCima:1: 1W 0deg
  FloquetCima:2, FloquetCima:3, FloquetCima:4, FloquetBaixo:1..FloquetBaixo:4: 0W 0deg

design G0985_anelQ_disco (HFSS, HFSS Modal Network, model units um)
variables:
  theta_inc = 0deg
geometry:
  Au_anelq [Au_JC] = box(corner=(-0.088um, -0.088um, 0um), size=(0.176um, 0.176um, 0.03um))
  Au_anelq_furo = box(corner=(-0.057um, -0.057um, 0um), size=(0.114um, 0.114um, 0.03um))
  Au_anelq.subtract(Au_anelq_furo)
  Au_disco = cylinder(axis=Z, base_centre=(0um, 0um, 0um), radius=0.047um, height=0.03um)
  Au_anelq.unite(Au_disco)
  Air_Domain [vacuum] = box(corner=(-0.16um, -0.16um, -1um), size=(0.32um, 0.32um, 2.03um))
  Au_anelq_1 = Au_anelq.copy()
  Air_Domain.subtract(Au_anelq_1)
boundaries and excitations:
  LatticePair_7PM5S7: Lattice Pair Faces=Air_Domain.face(-x, +x) CoordSysVector{(-0.16, -0.16, -1) -> (-0.16, -0.16, 1.03)} PhaseDelay=UseScanAngle Phi=0deg Theta=theta_inc
  LatticePair_7VOWGF: Lattice Pair Faces=Air_Domain.face(-y, +y) CoordSysVector{(0.16, -0.16, -1) -> (0.16, -0.16, 1.03)} PhaseDelay=UseScanAngle Phi=0deg Theta=theta_inc
  FloquetCima: Floquet Port Faces=Air_Domain.face(+z) NumModes=4 Modes{Mode1{CharImp=Zpi} Mode2{CharImp=Zpi} Mode3{CharImp=Zpi} Mode4{CharImp=Zpi}} PhaseDelay=UseScanAngle Phi=0deg Theta=theta_inc LatticeAVector{(-0.16, -0.16, 1.03) -> (0.16, -0.16, 1.03)} LatticeBVector{(-0.16, -0.16, 1.03) -> (-0.16, 0.16, 1.03)} ModesCalculator{Frequency=1GHz PhiStart=0deg PhiStop=0deg PhiStep=0deg ThetaStart=0deg ThetaStop=0deg ThetaStep=0deg} ModesList{Mode{ModeNumber=1 IndexM=0 IndexN=0 KC2=0 PropagationState=Undefined Attenuation=0 PolarizationState=TE AffectsRefinement} Mode{ModeNumber=2 IndexM=0 IndexN=0 KC2=0 PropagationState=Undefined Attenuation=0 PolarizationState=TM AffectsRefinement} Mode{ModeNumber=3 IndexM=-1 IndexN=0 KC2=385531421917553 PropagationState=Undefined Attenuation=1.7054704e+08 PolarizationState=TE AffectsRefinement} Mode{ModeNumber=4 IndexM=0 IndexN=-1 KC2=385531421917553 PropagationState=Undefined Attenuation=1.7054704e+08 PolarizationState=TE AffectsRefinement}}
  FloquetBaixo: Floquet Port Faces=Air_Domain.face(-z) NumModes=4 Modes{Mode1{CharImp=Zpi} Mode2{CharImp=Zpi} Mode3{CharImp=Zpi} Mode4{CharImp=Zpi}} PhaseDelay=UseScanAngle Phi=0deg Theta=theta_inc LatticeAVector{(-0.16, -0.16, -1) -> (0.16, -0.16, -1)} LatticeBVector{(-0.16, -0.16, -1) -> (-0.16, 0.16, -1)} ModesCalculator{Frequency=1GHz PhiStart=0deg PhiStop=0deg PhiStep=0deg ThetaStart=0deg ThetaStop=0deg ThetaStep=0deg} ModesList{Mode{ModeNumber=1 IndexM=0 IndexN=0 KC2=0 PropagationState=Undefined Attenuation=0 PolarizationState=TE AffectsRefinement} Mode{ModeNumber=2 IndexM=0 IndexN=0 KC2=0 PropagationState=Undefined Attenuation=0 PolarizationState=TM AffectsRefinement} Mode{ModeNumber=3 IndexM=-1 IndexN=0 KC2=385531421917553 PropagationState=Undefined Attenuation=1.7054704e+08 PolarizationState=TE AffectsRefinement} Mode{ModeNumber=4 IndexM=0 IndexN=-1 KC2=385531421917553 PropagationState=Undefined Attenuation=1.7054704e+08 PolarizationState=TE AffectsRefinement}}
setups:
  Setup1: HfssDriven Frequency=666.2THz MaxDeltaS=0.01 MaximumPasses=15 MinimumPasses=1 MinimumConvergedPasses=1 PercentRefinement=30 BasisOrder=1 PortAccuracy=2 DrivenSolverType="Direct Solver"
    sweep Varredura: 187.4THz to 666.2THz, 401 points; Type=Interpolating InterpTolerance=0.5 InterpMaxSolns=250 PassivityErrorTolerance=0.0001
source amplitudes:
  FloquetCima:1: 1W 0deg
  FloquetCima:2, FloquetCima:3, FloquetCima:4, FloquetBaixo:1..FloquetBaixo:4: 0W 0deg

design G0806_anelQ_disco (HFSS, HFSS Modal Network, model units um)
variables:
  theta_inc = 0deg
geometry:
  Au_anelq [Au_JC] = box(corner=(-0.104um, -0.104um, 0um), size=(0.208um, 0.208um, 0.03um))
  Au_anelq_furo = box(corner=(-0.065um, -0.065um, 0um), size=(0.13um, 0.13um, 0.03um))
  Au_anelq.subtract(Au_anelq_furo)
  Au_disco = cylinder(axis=Z, base_centre=(0um, 0um, 0um), radius=0.044um, height=0.03um)
  Au_anelq.unite(Au_disco)
  Air_Domain [vacuum] = box(corner=(-0.16um, -0.16um, -1um), size=(0.32um, 0.32um, 2.03um))
  Au_anelq_1 = Au_anelq.copy()
  Air_Domain.subtract(Au_anelq_1)
boundaries and excitations:
  LatticePair_JMRP4I: Lattice Pair Faces=Air_Domain.face(-x, +x) CoordSysVector{(-0.16, -0.16, -1) -> (-0.16, -0.16, 1.03)} PhaseDelay=UseScanAngle Phi=0deg Theta=theta_inc
  LatticePair_48PFM5: Lattice Pair Faces=Air_Domain.face(-y, +y) CoordSysVector{(0.16, -0.16, -1) -> (0.16, -0.16, 1.03)} PhaseDelay=UseScanAngle Phi=0deg Theta=theta_inc
  FloquetCima: Floquet Port Faces=Air_Domain.face(+z) NumModes=4 Modes{Mode1{CharImp=Zpi} Mode2{CharImp=Zpi} Mode3{CharImp=Zpi} Mode4{CharImp=Zpi}} PhaseDelay=UseScanAngle Phi=0deg Theta=theta_inc LatticeAVector{(-0.16, -0.16, 1.03) -> (0.16, -0.16, 1.03)} LatticeBVector{(-0.16, -0.16, 1.03) -> (-0.16, 0.16, 1.03)} ModesCalculator{Frequency=1GHz PhiStart=0deg PhiStop=0deg PhiStep=0deg ThetaStart=0deg ThetaStop=0deg ThetaStep=0deg} ModesList{Mode{ModeNumber=1 IndexM=0 IndexN=0 KC2=0 PropagationState=Undefined Attenuation=0 PolarizationState=TE AffectsRefinement} Mode{ModeNumber=2 IndexM=0 IndexN=0 KC2=0 PropagationState=Undefined Attenuation=0 PolarizationState=TM AffectsRefinement} Mode{ModeNumber=3 IndexM=-1 IndexN=0 KC2=385531421917553 PropagationState=Undefined Attenuation=1.7054704e+08 PolarizationState=TE AffectsRefinement} Mode{ModeNumber=4 IndexM=0 IndexN=-1 KC2=385531421917553 PropagationState=Undefined Attenuation=1.7054704e+08 PolarizationState=TE AffectsRefinement}}
  FloquetBaixo: Floquet Port Faces=Air_Domain.face(-z) NumModes=4 Modes{Mode1{CharImp=Zpi} Mode2{CharImp=Zpi} Mode3{CharImp=Zpi} Mode4{CharImp=Zpi}} PhaseDelay=UseScanAngle Phi=0deg Theta=theta_inc LatticeAVector{(-0.16, -0.16, -1) -> (0.16, -0.16, -1)} LatticeBVector{(-0.16, -0.16, -1) -> (-0.16, 0.16, -1)} ModesCalculator{Frequency=1GHz PhiStart=0deg PhiStop=0deg PhiStep=0deg ThetaStart=0deg ThetaStop=0deg ThetaStep=0deg} ModesList{Mode{ModeNumber=1 IndexM=0 IndexN=0 KC2=0 PropagationState=Undefined Attenuation=0 PolarizationState=TE AffectsRefinement} Mode{ModeNumber=2 IndexM=0 IndexN=0 KC2=0 PropagationState=Undefined Attenuation=0 PolarizationState=TM AffectsRefinement} Mode{ModeNumber=3 IndexM=-1 IndexN=0 KC2=385531421917553 PropagationState=Undefined Attenuation=1.7054704e+08 PolarizationState=TE AffectsRefinement} Mode{ModeNumber=4 IndexM=0 IndexN=-1 KC2=385531421917553 PropagationState=Undefined Attenuation=1.7054704e+08 PolarizationState=TE AffectsRefinement}}
setups:
  Setup1: HfssDriven Frequency=666.2THz MaxDeltaS=0.01 MaximumPasses=15 MinimumPasses=1 MinimumConvergedPasses=1 PercentRefinement=30 BasisOrder=1 PortAccuracy=2 DrivenSolverType="Direct Solver"
    sweep Varredura: 187.4THz to 666.2THz, 401 points; Type=Interpolating InterpTolerance=0.5 InterpMaxSolns=250 PassivityErrorTolerance=0.0001
source amplitudes:
  FloquetCima:1: 1W 0deg
  FloquetCima:2, FloquetCima:3, FloquetCima:4, FloquetBaixo:1..FloquetBaixo:4: 0W 0deg

design G0895_anelQ_disco (HFSS, HFSS Modal Network, model units um)
variables:
  theta_inc = 0deg
geometry:
  Au_anelq [Au_JC] = box(corner=(-0.08um, -0.08um, 0um), size=(0.16um, 0.16um, 0.03um))
  Au_anelq_furo = box(corner=(-0.05um, -0.05um, 0um), size=(0.1um, 0.1um, 0.03um))
  Au_anelq.subtract(Au_anelq_furo)
  Au_disco = cylinder(axis=Z, base_centre=(0um, 0um, 0um), radius=0.021um, height=0.03um)
  Au_anelq.unite(Au_disco)
  Air_Domain [vacuum] = box(corner=(-0.16um, -0.16um, -1um), size=(0.32um, 0.32um, 2.03um))
  Au_anelq_1 = Au_anelq.copy()
  Air_Domain.subtract(Au_anelq_1)
boundaries and excitations:
  LatticePair_B1RBLU: Lattice Pair Faces=Air_Domain.face(-x, +x) CoordSysVector{(-0.16, -0.16, -1) -> (-0.16, -0.16, 1.03)} PhaseDelay=UseScanAngle Phi=0deg Theta=theta_inc
  LatticePair_4SWLDV: Lattice Pair Faces=Air_Domain.face(-y, +y) CoordSysVector{(0.16, -0.16, -1) -> (0.16, -0.16, 1.03)} PhaseDelay=UseScanAngle Phi=0deg Theta=theta_inc
  FloquetCima: Floquet Port Faces=Air_Domain.face(+z) NumModes=4 Modes{Mode1{CharImp=Zpi} Mode2{CharImp=Zpi} Mode3{CharImp=Zpi} Mode4{CharImp=Zpi}} PhaseDelay=UseScanAngle Phi=0deg Theta=theta_inc LatticeAVector{(-0.16, -0.16, 1.03) -> (0.16, -0.16, 1.03)} LatticeBVector{(-0.16, -0.16, 1.03) -> (-0.16, 0.16, 1.03)} ModesCalculator{Frequency=1GHz PhiStart=0deg PhiStop=0deg PhiStep=0deg ThetaStart=0deg ThetaStop=0deg ThetaStep=0deg} ModesList{Mode{ModeNumber=1 IndexM=0 IndexN=0 KC2=0 PropagationState=Undefined Attenuation=0 PolarizationState=TE AffectsRefinement} Mode{ModeNumber=2 IndexM=0 IndexN=0 KC2=0 PropagationState=Undefined Attenuation=0 PolarizationState=TM AffectsRefinement} Mode{ModeNumber=3 IndexM=-1 IndexN=0 KC2=385531421917553 PropagationState=Undefined Attenuation=1.7054704e+08 PolarizationState=TE AffectsRefinement} Mode{ModeNumber=4 IndexM=0 IndexN=-1 KC2=385531421917553 PropagationState=Undefined Attenuation=1.7054704e+08 PolarizationState=TE AffectsRefinement}}
  FloquetBaixo: Floquet Port Faces=Air_Domain.face(-z) NumModes=4 Modes{Mode1{CharImp=Zpi} Mode2{CharImp=Zpi} Mode3{CharImp=Zpi} Mode4{CharImp=Zpi}} PhaseDelay=UseScanAngle Phi=0deg Theta=theta_inc LatticeAVector{(-0.16, -0.16, -1) -> (0.16, -0.16, -1)} LatticeBVector{(-0.16, -0.16, -1) -> (-0.16, 0.16, -1)} ModesCalculator{Frequency=1GHz PhiStart=0deg PhiStop=0deg PhiStep=0deg ThetaStart=0deg ThetaStop=0deg ThetaStep=0deg} ModesList{Mode{ModeNumber=1 IndexM=0 IndexN=0 KC2=0 PropagationState=Undefined Attenuation=0 PolarizationState=TE AffectsRefinement} Mode{ModeNumber=2 IndexM=0 IndexN=0 KC2=0 PropagationState=Undefined Attenuation=0 PolarizationState=TM AffectsRefinement} Mode{ModeNumber=3 IndexM=-1 IndexN=0 KC2=385531421917553 PropagationState=Undefined Attenuation=1.7054704e+08 PolarizationState=TE AffectsRefinement} Mode{ModeNumber=4 IndexM=0 IndexN=-1 KC2=385531421917553 PropagationState=Undefined Attenuation=1.7054704e+08 PolarizationState=TE AffectsRefinement}}
setups:
  Setup1: HfssDriven Frequency=666.2THz MaxDeltaS=0.01 MaximumPasses=15 MinimumPasses=1 MinimumConvergedPasses=1 PercentRefinement=30 BasisOrder=1 PortAccuracy=2 DrivenSolverType="Direct Solver"
    sweep Varredura: 187.4THz to 666.2THz, 401 points; Type=Interpolating InterpTolerance=0.5 InterpMaxSolns=250 PassivityErrorTolerance=0.0001
source amplitudes:
  FloquetCima:1: 1W 0deg
  FloquetCima:2, FloquetCima:3, FloquetCima:4, FloquetBaixo:1..FloquetBaixo:4: 0W 0deg

design G0939_anelQ_disco (HFSS, HFSS Modal Network, model units um)
variables:
  theta_inc = 0deg
geometry:
  Au_anelq [Au_JC] = box(corner=(-0.0945um, -0.0945um, 0um), size=(0.189um, 0.189um, 0.03um))
  Au_anelq_furo = box(corner=(-0.0585um, -0.0585um, 0um), size=(0.117um, 0.117um, 0.03um))
  Au_anelq.subtract(Au_anelq_furo)
  Au_disco = cylinder(axis=Z, base_centre=(0um, 0um, 0um), radius=0.024um, height=0.03um)
  Au_anelq.unite(Au_disco)
  Air_Domain [vacuum] = box(corner=(-0.16um, -0.16um, -1um), size=(0.32um, 0.32um, 2.03um))
  Au_anelq_1 = Au_anelq.copy()
  Air_Domain.subtract(Au_anelq_1)
boundaries and excitations:
  LatticePair_0ZZQ0M: Lattice Pair Faces=Air_Domain.face(-x, +x) CoordSysVector{(-0.16, -0.16, -1) -> (-0.16, -0.16, 1.03)} PhaseDelay=UseScanAngle Phi=0deg Theta=theta_inc
  LatticePair_4SO16A: Lattice Pair Faces=Air_Domain.face(-y, +y) CoordSysVector{(0.16, -0.16, -1) -> (0.16, -0.16, 1.03)} PhaseDelay=UseScanAngle Phi=0deg Theta=theta_inc
  FloquetCima: Floquet Port Faces=Air_Domain.face(+z) NumModes=4 Modes{Mode1{CharImp=Zpi} Mode2{CharImp=Zpi} Mode3{CharImp=Zpi} Mode4{CharImp=Zpi}} PhaseDelay=UseScanAngle Phi=0deg Theta=theta_inc LatticeAVector{(-0.16, -0.16, 1.03) -> (0.16, -0.16, 1.03)} LatticeBVector{(-0.16, -0.16, 1.03) -> (-0.16, 0.16, 1.03)} ModesCalculator{Frequency=1GHz PhiStart=0deg PhiStop=0deg PhiStep=0deg ThetaStart=0deg ThetaStop=0deg ThetaStep=0deg} ModesList{Mode{ModeNumber=1 IndexM=0 IndexN=0 KC2=0 PropagationState=Undefined Attenuation=0 PolarizationState=TE AffectsRefinement} Mode{ModeNumber=2 IndexM=0 IndexN=0 KC2=0 PropagationState=Undefined Attenuation=0 PolarizationState=TM AffectsRefinement} Mode{ModeNumber=3 IndexM=-1 IndexN=0 KC2=385531421917553 PropagationState=Undefined Attenuation=1.7054704e+08 PolarizationState=TE AffectsRefinement} Mode{ModeNumber=4 IndexM=0 IndexN=-1 KC2=385531421917553 PropagationState=Undefined Attenuation=1.7054704e+08 PolarizationState=TE AffectsRefinement}}
  FloquetBaixo: Floquet Port Faces=Air_Domain.face(-z) NumModes=4 Modes{Mode1{CharImp=Zpi} Mode2{CharImp=Zpi} Mode3{CharImp=Zpi} Mode4{CharImp=Zpi}} PhaseDelay=UseScanAngle Phi=0deg Theta=theta_inc LatticeAVector{(-0.16, -0.16, -1) -> (0.16, -0.16, -1)} LatticeBVector{(-0.16, -0.16, -1) -> (-0.16, 0.16, -1)} ModesCalculator{Frequency=1GHz PhiStart=0deg PhiStop=0deg PhiStep=0deg ThetaStart=0deg ThetaStop=0deg ThetaStep=0deg} ModesList{Mode{ModeNumber=1 IndexM=0 IndexN=0 KC2=0 PropagationState=Undefined Attenuation=0 PolarizationState=TE AffectsRefinement} Mode{ModeNumber=2 IndexM=0 IndexN=0 KC2=0 PropagationState=Undefined Attenuation=0 PolarizationState=TM AffectsRefinement} Mode{ModeNumber=3 IndexM=-1 IndexN=0 KC2=385531421917553 PropagationState=Undefined Attenuation=1.7054704e+08 PolarizationState=TE AffectsRefinement} Mode{ModeNumber=4 IndexM=0 IndexN=-1 KC2=385531421917553 PropagationState=Undefined Attenuation=1.7054704e+08 PolarizationState=TE AffectsRefinement}}
setups:
  Setup1: HfssDriven Frequency=666.2THz MaxDeltaS=0.01 MaximumPasses=15 MinimumPasses=1 MinimumConvergedPasses=1 PercentRefinement=30 BasisOrder=1 PortAccuracy=2 DrivenSolverType="Direct Solver"
    sweep Varredura: 187.4THz to 666.2THz, 401 points; Type=Interpolating InterpTolerance=0.5 InterpMaxSolns=250 PassivityErrorTolerance=0.0001
source amplitudes:
  FloquetCima:1: 1W 0deg
  FloquetCima:2, FloquetCima:3, FloquetCima:4, FloquetBaixo:1..FloquetBaixo:4: 0W 0deg

design G1159_anelQ_disco_trilhas (HFSS, HFSS Modal Network, model units um)
variables:
  theta_inc = 0deg
geometry:
  Au_anelq [Au_JC] = box(corner=(-0.0805um, -0.0805um, 0um), size=(0.161um, 0.161um, 0.03um))
  Au_anelq_furo = box(corner=(-0.0365um, -0.0365um, 0um), size=(0.073um, 0.073um, 0.03um))
  Au_anelq.subtract(Au_anelq_furo)
  Au_disco = cylinder(axis=Z, base_centre=(0um, 0um, 0um), radius=0.023um, height=0.03um)
  Au_trilha0 = box(corner=(0.013um, -0.0115um, 0um), size=(0.0455um, 0.023um, 0.03um))
  Au_trilha1 = box(corner=(-0.0585um, -0.0115um, 0um), size=(0.0455um, 0.023um, 0.03um))
  Au_trilha2 = box(corner=(-0.0115um, 0.013um, 0um), size=(0.023um, 0.0455um, 0.03um))
  Au_trilha3 = box(corner=(-0.0115um, -0.0585um, 0um), size=(0.023um, 0.0455um, 0.03um))
  Au_anelq.unite(Au_disco, Au_trilha0..Au_trilha3)
  Air_Domain [vacuum] = box(corner=(-0.16um, -0.16um, -1um), size=(0.32um, 0.32um, 2.03um))
  Au_anelq_1 = Au_anelq.copy()
  Air_Domain.subtract(Au_anelq_1)
boundaries and excitations:
  LatticePair_H4VG2W: Lattice Pair Faces=Air_Domain.face(-x, +x) CoordSysVector{(-0.16, -0.16, -1) -> (-0.16, -0.16, 1.03)} PhaseDelay=UseScanAngle Phi=0deg Theta=theta_inc
  LatticePair_HDLIAU: Lattice Pair Faces=Air_Domain.face(-y, +y) CoordSysVector{(0.16, -0.16, -1) -> (0.16, -0.16, 1.03)} PhaseDelay=UseScanAngle Phi=0deg Theta=theta_inc
  FloquetCima: Floquet Port Faces=Air_Domain.face(+z) NumModes=4 Modes{Mode1{CharImp=Zpi} Mode2{CharImp=Zpi} Mode3{CharImp=Zpi} Mode4{CharImp=Zpi}} PhaseDelay=UseScanAngle Phi=0deg Theta=theta_inc LatticeAVector{(-0.16, -0.16, 1.03) -> (0.16, -0.16, 1.03)} LatticeBVector{(-0.16, -0.16, 1.03) -> (-0.16, 0.16, 1.03)} ModesCalculator{Frequency=1GHz PhiStart=0deg PhiStop=0deg PhiStep=0deg ThetaStart=0deg ThetaStop=0deg ThetaStep=0deg} ModesList{Mode{ModeNumber=1 IndexM=0 IndexN=0 KC2=0 PropagationState=Undefined Attenuation=0 PolarizationState=TE AffectsRefinement} Mode{ModeNumber=2 IndexM=0 IndexN=0 KC2=0 PropagationState=Undefined Attenuation=0 PolarizationState=TM AffectsRefinement} Mode{ModeNumber=3 IndexM=-1 IndexN=0 KC2=385531421917553 PropagationState=Undefined Attenuation=1.7054704e+08 PolarizationState=TE AffectsRefinement} Mode{ModeNumber=4 IndexM=0 IndexN=-1 KC2=385531421917553 PropagationState=Undefined Attenuation=1.7054704e+08 PolarizationState=TE AffectsRefinement}}
  FloquetBaixo: Floquet Port Faces=Air_Domain.face(-z) NumModes=4 Modes{Mode1{CharImp=Zpi} Mode2{CharImp=Zpi} Mode3{CharImp=Zpi} Mode4{CharImp=Zpi}} PhaseDelay=UseScanAngle Phi=0deg Theta=theta_inc LatticeAVector{(-0.16, -0.16, -1) -> (0.16, -0.16, -1)} LatticeBVector{(-0.16, -0.16, -1) -> (-0.16, 0.16, -1)} ModesCalculator{Frequency=1GHz PhiStart=0deg PhiStop=0deg PhiStep=0deg ThetaStart=0deg ThetaStop=0deg ThetaStep=0deg} ModesList{Mode{ModeNumber=1 IndexM=0 IndexN=0 KC2=0 PropagationState=Undefined Attenuation=0 PolarizationState=TE AffectsRefinement} Mode{ModeNumber=2 IndexM=0 IndexN=0 KC2=0 PropagationState=Undefined Attenuation=0 PolarizationState=TM AffectsRefinement} Mode{ModeNumber=3 IndexM=-1 IndexN=0 KC2=385531421917553 PropagationState=Undefined Attenuation=1.7054704e+08 PolarizationState=TE AffectsRefinement} Mode{ModeNumber=4 IndexM=0 IndexN=-1 KC2=385531421917553 PropagationState=Undefined Attenuation=1.7054704e+08 PolarizationState=TE AffectsRefinement}}
setups:
  Setup1: HfssDriven Frequency=666.2THz MaxDeltaS=0.01 MaximumPasses=15 MinimumPasses=1 MinimumConvergedPasses=1 PercentRefinement=30 BasisOrder=1 PortAccuracy=2 DrivenSolverType="Direct Solver"
    sweep Varredura: 187.4THz to 666.2THz, 401 points; Type=Interpolating InterpTolerance=0.5 InterpMaxSolns=250 PassivityErrorTolerance=0.0001
source amplitudes:
  FloquetCima:1: 1W 0deg
  FloquetCima:2, FloquetCima:3, FloquetCima:4, FloquetBaixo:1..FloquetBaixo:4: 0W 0deg

design G1023_anelQ_disco_trilhas (HFSS, HFSS Modal Network, model units um)
variables:
  theta_inc = 0deg
geometry:
  Au_anelq [Au_JC] = box(corner=(-0.0855um, -0.0855um, 0um), size=(0.171um, 0.171um, 0.03um))
  Au_anelq_furo = box(corner=(-0.0475um, -0.0475um, 0um), size=(0.095um, 0.095um, 0.03um))
  Au_anelq.subtract(Au_anelq_furo)
  Au_disco = cylinder(axis=Z, base_centre=(0um, 0um, 0um), radius=0.026um, height=0.03um)
  Au_trilha0 = box(corner=(0.016um, -0.0115um, 0um), size=(0.0505um, 0.023um, 0.03um))
  Au_trilha1 = box(corner=(-0.0665um, -0.0115um, 0um), size=(0.0505um, 0.023um, 0.03um))
  Au_trilha2 = box(corner=(-0.0115um, 0.016um, 0um), size=(0.023um, 0.0505um, 0.03um))
  Au_trilha3 = box(corner=(-0.0115um, -0.0665um, 0um), size=(0.023um, 0.0505um, 0.03um))
  Au_anelq.unite(Au_disco, Au_trilha0..Au_trilha3)
  Air_Domain [vacuum] = box(corner=(-0.16um, -0.16um, -1um), size=(0.32um, 0.32um, 2.03um))
  Au_anelq_1 = Au_anelq.copy()
  Air_Domain.subtract(Au_anelq_1)
boundaries and excitations:
  LatticePair_23MMWW: Lattice Pair Faces=Air_Domain.face(-x, +x) CoordSysVector{(-0.16, -0.16, -1) -> (-0.16, -0.16, 1.03)} PhaseDelay=UseScanAngle Phi=0deg Theta=theta_inc
  LatticePair_ALD3XN: Lattice Pair Faces=Air_Domain.face(-y, +y) CoordSysVector{(0.16, -0.16, -1) -> (0.16, -0.16, 1.03)} PhaseDelay=UseScanAngle Phi=0deg Theta=theta_inc
  FloquetCima: Floquet Port Faces=Air_Domain.face(+z) NumModes=4 Modes{Mode1{CharImp=Zpi} Mode2{CharImp=Zpi} Mode3{CharImp=Zpi} Mode4{CharImp=Zpi}} PhaseDelay=UseScanAngle Phi=0deg Theta=theta_inc LatticeAVector{(-0.16, -0.16, 1.03) -> (0.16, -0.16, 1.03)} LatticeBVector{(-0.16, -0.16, 1.03) -> (-0.16, 0.16, 1.03)} ModesCalculator{Frequency=1GHz PhiStart=0deg PhiStop=0deg PhiStep=0deg ThetaStart=0deg ThetaStop=0deg ThetaStep=0deg} ModesList{Mode{ModeNumber=1 IndexM=0 IndexN=0 KC2=0 PropagationState=Undefined Attenuation=0 PolarizationState=TE AffectsRefinement} Mode{ModeNumber=2 IndexM=0 IndexN=0 KC2=0 PropagationState=Undefined Attenuation=0 PolarizationState=TM AffectsRefinement} Mode{ModeNumber=3 IndexM=-1 IndexN=0 KC2=385531421917553 PropagationState=Undefined Attenuation=1.7054704e+08 PolarizationState=TE AffectsRefinement} Mode{ModeNumber=4 IndexM=0 IndexN=-1 KC2=385531421917553 PropagationState=Undefined Attenuation=1.7054704e+08 PolarizationState=TE AffectsRefinement}}
  FloquetBaixo: Floquet Port Faces=Air_Domain.face(-z) NumModes=4 Modes{Mode1{CharImp=Zpi} Mode2{CharImp=Zpi} Mode3{CharImp=Zpi} Mode4{CharImp=Zpi}} PhaseDelay=UseScanAngle Phi=0deg Theta=theta_inc LatticeAVector{(-0.16, -0.16, -1) -> (0.16, -0.16, -1)} LatticeBVector{(-0.16, -0.16, -1) -> (-0.16, 0.16, -1)} ModesCalculator{Frequency=1GHz PhiStart=0deg PhiStop=0deg PhiStep=0deg ThetaStart=0deg ThetaStop=0deg ThetaStep=0deg} ModesList{Mode{ModeNumber=1 IndexM=0 IndexN=0 KC2=0 PropagationState=Undefined Attenuation=0 PolarizationState=TE AffectsRefinement} Mode{ModeNumber=2 IndexM=0 IndexN=0 KC2=0 PropagationState=Undefined Attenuation=0 PolarizationState=TM AffectsRefinement} Mode{ModeNumber=3 IndexM=-1 IndexN=0 KC2=385531421917553 PropagationState=Undefined Attenuation=1.7054704e+08 PolarizationState=TE AffectsRefinement} Mode{ModeNumber=4 IndexM=0 IndexN=-1 KC2=385531421917553 PropagationState=Undefined Attenuation=1.7054704e+08 PolarizationState=TE AffectsRefinement}}
setups:
  Setup1: HfssDriven Frequency=666.2THz MaxDeltaS=0.01 MaximumPasses=15 MinimumPasses=1 MinimumConvergedPasses=1 PercentRefinement=30 BasisOrder=1 PortAccuracy=2 DrivenSolverType="Direct Solver"
    sweep Varredura: 187.4THz to 666.2THz, 401 points; Type=Interpolating InterpTolerance=0.5 InterpMaxSolns=250 PassivityErrorTolerance=0.0001
source amplitudes:
  FloquetCima:1: 1W 0deg
  FloquetCima:2, FloquetCima:3, FloquetCima:4, FloquetBaixo:1..FloquetBaixo:4: 0W 0deg

design G1125_anelQ_disco_trilhas (HFSS, HFSS Modal Network, model units um)
variables:
  theta_inc = 0deg
geometry:
  Au_anelq [Au_JC] = box(corner=(-0.087um, -0.087um, 0um), size=(0.174um, 0.174um, 0.03um))
  Au_anelq_furo = box(corner=(-0.059um, -0.059um, 0um), size=(0.118um, 0.118um, 0.03um))
  Au_anelq.subtract(Au_anelq_furo)
  Au_disco = cylinder(axis=Z, base_centre=(0um, 0um, 0um), radius=0.047um, height=0.03um)
  Au_trilha0 = box(corner=(0.037um, -0.0135um, 0um), size=(0.036um, 0.027um, 0.03um))
  Au_trilha1 = box(corner=(-0.073um, -0.0135um, 0um), size=(0.036um, 0.027um, 0.03um))
  Au_trilha2 = box(corner=(-0.0135um, 0.037um, 0um), size=(0.027um, 0.036um, 0.03um))
  Au_trilha3 = box(corner=(-0.0135um, -0.073um, 0um), size=(0.027um, 0.036um, 0.03um))
  Au_anelq.unite(Au_disco, Au_trilha0..Au_trilha3)
  Air_Domain [vacuum] = box(corner=(-0.16um, -0.16um, -1um), size=(0.32um, 0.32um, 2.03um))
  Au_anelq_1 = Au_anelq.copy()
  Air_Domain.subtract(Au_anelq_1)
boundaries and excitations:
  LatticePair_C6UGQ6: Lattice Pair Faces=Air_Domain.face(-x, +x) CoordSysVector{(-0.16, -0.16, -1) -> (-0.16, -0.16, 1.03)} PhaseDelay=UseScanAngle Phi=0deg Theta=theta_inc
  LatticePair_LL2ORO: Lattice Pair Faces=Air_Domain.face(-y, +y) CoordSysVector{(0.16, -0.16, -1) -> (0.16, -0.16, 1.03)} PhaseDelay=UseScanAngle Phi=0deg Theta=theta_inc
  FloquetCima: Floquet Port Faces=Air_Domain.face(+z) NumModes=4 Modes{Mode1{CharImp=Zpi} Mode2{CharImp=Zpi} Mode3{CharImp=Zpi} Mode4{CharImp=Zpi}} PhaseDelay=UseScanAngle Phi=0deg Theta=theta_inc LatticeAVector{(-0.16, -0.16, 1.03) -> (0.16, -0.16, 1.03)} LatticeBVector{(-0.16, -0.16, 1.03) -> (-0.16, 0.16, 1.03)} ModesCalculator{Frequency=1GHz PhiStart=0deg PhiStop=0deg PhiStep=0deg ThetaStart=0deg ThetaStop=0deg ThetaStep=0deg} ModesList{Mode{ModeNumber=1 IndexM=0 IndexN=0 KC2=0 PropagationState=Undefined Attenuation=0 PolarizationState=TE AffectsRefinement} Mode{ModeNumber=2 IndexM=0 IndexN=0 KC2=0 PropagationState=Undefined Attenuation=0 PolarizationState=TM AffectsRefinement} Mode{ModeNumber=3 IndexM=-1 IndexN=0 KC2=385531421917553 PropagationState=Undefined Attenuation=1.7054704e+08 PolarizationState=TE AffectsRefinement} Mode{ModeNumber=4 IndexM=0 IndexN=-1 KC2=385531421917553 PropagationState=Undefined Attenuation=1.7054704e+08 PolarizationState=TE AffectsRefinement}}
  FloquetBaixo: Floquet Port Faces=Air_Domain.face(-z) NumModes=4 Modes{Mode1{CharImp=Zpi} Mode2{CharImp=Zpi} Mode3{CharImp=Zpi} Mode4{CharImp=Zpi}} PhaseDelay=UseScanAngle Phi=0deg Theta=theta_inc LatticeAVector{(-0.16, -0.16, -1) -> (0.16, -0.16, -1)} LatticeBVector{(-0.16, -0.16, -1) -> (-0.16, 0.16, -1)} ModesCalculator{Frequency=1GHz PhiStart=0deg PhiStop=0deg PhiStep=0deg ThetaStart=0deg ThetaStop=0deg ThetaStep=0deg} ModesList{Mode{ModeNumber=1 IndexM=0 IndexN=0 KC2=0 PropagationState=Undefined Attenuation=0 PolarizationState=TE AffectsRefinement} Mode{ModeNumber=2 IndexM=0 IndexN=0 KC2=0 PropagationState=Undefined Attenuation=0 PolarizationState=TM AffectsRefinement} Mode{ModeNumber=3 IndexM=-1 IndexN=0 KC2=385531421917553 PropagationState=Undefined Attenuation=1.7054704e+08 PolarizationState=TE AffectsRefinement} Mode{ModeNumber=4 IndexM=0 IndexN=-1 KC2=385531421917553 PropagationState=Undefined Attenuation=1.7054704e+08 PolarizationState=TE AffectsRefinement}}
setups:
  Setup1: HfssDriven Frequency=666.2THz MaxDeltaS=0.01 MaximumPasses=15 MinimumPasses=1 MinimumConvergedPasses=1 PercentRefinement=30 BasisOrder=1 PortAccuracy=2 DrivenSolverType="Direct Solver"
    sweep Varredura: 187.4THz to 666.2THz, 401 points; Type=Interpolating InterpTolerance=0.5 InterpMaxSolns=250 PassivityErrorTolerance=0.0001
source amplitudes:
  FloquetCima:1: 1W 0deg
  FloquetCima:2, FloquetCima:3, FloquetCima:4, FloquetBaixo:1..FloquetBaixo:4: 0W 0deg

design G1084_anelQ_disco_trilhas (HFSS, HFSS Modal Network, model units um)
variables:
  theta_inc = 0deg
geometry:
  Au_anelq [Au_JC] = box(corner=(-0.095um, -0.095um, 0um), size=(0.19um, 0.19um, 0.03um))
  Au_anelq_furo = box(corner=(-0.067um, -0.067um, 0um), size=(0.134um, 0.134um, 0.03um))
  Au_anelq.subtract(Au_anelq_furo)
  Au_disco = cylinder(axis=Z, base_centre=(0um, 0um, 0um), radius=0.039um, height=0.03um)
  Au_trilha0 = box(corner=(0.029um, -0.013um, 0um), size=(0.052um, 0.026um, 0.03um))
  Au_trilha1 = box(corner=(-0.081um, -0.013um, 0um), size=(0.052um, 0.026um, 0.03um))
  Au_trilha2 = box(corner=(-0.013um, 0.029um, 0um), size=(0.026um, 0.052um, 0.03um))
  Au_trilha3 = box(corner=(-0.013um, -0.081um, 0um), size=(0.026um, 0.052um, 0.03um))
  Au_anelq.unite(Au_disco, Au_trilha0..Au_trilha3)
  Air_Domain [vacuum] = box(corner=(-0.16um, -0.16um, -1um), size=(0.32um, 0.32um, 2.03um))
  Au_anelq_1 = Au_anelq.copy()
  Air_Domain.subtract(Au_anelq_1)
boundaries and excitations:
  LatticePair_TQZ9J7: Lattice Pair Faces=Air_Domain.face(-x, +x) CoordSysVector{(-0.16, -0.16, -1) -> (-0.16, -0.16, 1.03)} PhaseDelay=UseScanAngle Phi=0deg Theta=theta_inc
  LatticePair_KS7QTI: Lattice Pair Faces=Air_Domain.face(-y, +y) CoordSysVector{(0.16, -0.16, -1) -> (0.16, -0.16, 1.03)} PhaseDelay=UseScanAngle Phi=0deg Theta=theta_inc
  FloquetCima: Floquet Port Faces=Air_Domain.face(+z) NumModes=4 Modes{Mode1{CharImp=Zpi} Mode2{CharImp=Zpi} Mode3{CharImp=Zpi} Mode4{CharImp=Zpi}} PhaseDelay=UseScanAngle Phi=0deg Theta=theta_inc LatticeAVector{(-0.16, -0.16, 1.03) -> (0.16, -0.16, 1.03)} LatticeBVector{(-0.16, -0.16, 1.03) -> (-0.16, 0.16, 1.03)} ModesCalculator{Frequency=1GHz PhiStart=0deg PhiStop=0deg PhiStep=0deg ThetaStart=0deg ThetaStop=0deg ThetaStep=0deg} ModesList{Mode{ModeNumber=1 IndexM=0 IndexN=0 KC2=0 PropagationState=Undefined Attenuation=0 PolarizationState=TE AffectsRefinement} Mode{ModeNumber=2 IndexM=0 IndexN=0 KC2=0 PropagationState=Undefined Attenuation=0 PolarizationState=TM AffectsRefinement} Mode{ModeNumber=3 IndexM=-1 IndexN=0 KC2=385531421917553 PropagationState=Undefined Attenuation=1.7054704e+08 PolarizationState=TE AffectsRefinement} Mode{ModeNumber=4 IndexM=0 IndexN=-1 KC2=385531421917553 PropagationState=Undefined Attenuation=1.7054704e+08 PolarizationState=TE AffectsRefinement}}
  FloquetBaixo: Floquet Port Faces=Air_Domain.face(-z) NumModes=4 Modes{Mode1{CharImp=Zpi} Mode2{CharImp=Zpi} Mode3{CharImp=Zpi} Mode4{CharImp=Zpi}} PhaseDelay=UseScanAngle Phi=0deg Theta=theta_inc LatticeAVector{(-0.16, -0.16, -1) -> (0.16, -0.16, -1)} LatticeBVector{(-0.16, -0.16, -1) -> (-0.16, 0.16, -1)} ModesCalculator{Frequency=1GHz PhiStart=0deg PhiStop=0deg PhiStep=0deg ThetaStart=0deg ThetaStop=0deg ThetaStep=0deg} ModesList{Mode{ModeNumber=1 IndexM=0 IndexN=0 KC2=0 PropagationState=Undefined Attenuation=0 PolarizationState=TE AffectsRefinement} Mode{ModeNumber=2 IndexM=0 IndexN=0 KC2=0 PropagationState=Undefined Attenuation=0 PolarizationState=TM AffectsRefinement} Mode{ModeNumber=3 IndexM=-1 IndexN=0 KC2=385531421917553 PropagationState=Undefined Attenuation=1.7054704e+08 PolarizationState=TE AffectsRefinement} Mode{ModeNumber=4 IndexM=0 IndexN=-1 KC2=385531421917553 PropagationState=Undefined Attenuation=1.7054704e+08 PolarizationState=TE AffectsRefinement}}
setups:
  Setup1: HfssDriven Frequency=666.2THz MaxDeltaS=0.01 MaximumPasses=15 MinimumPasses=1 MinimumConvergedPasses=1 PercentRefinement=30 BasisOrder=1 PortAccuracy=2 DrivenSolverType="Direct Solver"
    sweep Varredura: 187.4THz to 666.2THz, 401 points; Type=Interpolating InterpTolerance=0.5 InterpMaxSolns=250 PassivityErrorTolerance=0.0001
source amplitudes:
  FloquetCima:1: 1W 0deg
  FloquetCima:2, FloquetCima:3, FloquetCima:4, FloquetBaixo:1..FloquetBaixo:4: 0W 0deg

design G1046_anelQ_disco_trilhas (HFSS, HFSS Modal Network, model units um)
variables:
  theta_inc = 0deg
geometry:
  Au_anelq [Au_JC] = box(corner=(-0.1055um, -0.1055um, 0um), size=(0.211um, 0.211um, 0.03um))
  Au_anelq_furo = box(corner=(-0.0665um, -0.0665um, 0um), size=(0.133um, 0.133um, 0.03um))
  Au_anelq.subtract(Au_anelq_furo)
  Au_disco = cylinder(axis=Z, base_centre=(0um, 0um, 0um), radius=0.02um, height=0.03um)
  Au_trilha0 = box(corner=(0.01um, -0.0145um, 0um), size=(0.076um, 0.029um, 0.03um))
  Au_trilha1 = box(corner=(-0.086um, -0.0145um, 0um), size=(0.076um, 0.029um, 0.03um))
  Au_trilha2 = box(corner=(-0.0145um, 0.01um, 0um), size=(0.029um, 0.076um, 0.03um))
  Au_trilha3 = box(corner=(-0.0145um, -0.086um, 0um), size=(0.029um, 0.076um, 0.03um))
  Au_anelq.unite(Au_disco, Au_trilha0..Au_trilha3)
  Air_Domain [vacuum] = box(corner=(-0.16um, -0.16um, -1um), size=(0.32um, 0.32um, 2.03um))
  Au_anelq_1 = Au_anelq.copy()
  Air_Domain.subtract(Au_anelq_1)
boundaries and excitations:
  LatticePair_LVJL8J: Lattice Pair Faces=Air_Domain.face(-x, +x) CoordSysVector{(-0.16, -0.16, -1) -> (-0.16, -0.16, 1.03)} PhaseDelay=UseScanAngle Phi=0deg Theta=theta_inc
  LatticePair_3835CP: Lattice Pair Faces=Air_Domain.face(-y, +y) CoordSysVector{(0.16, -0.16, -1) -> (0.16, -0.16, 1.03)} PhaseDelay=UseScanAngle Phi=0deg Theta=theta_inc
  FloquetCima: Floquet Port Faces=Air_Domain.face(+z) NumModes=4 Modes{Mode1{CharImp=Zpi} Mode2{CharImp=Zpi} Mode3{CharImp=Zpi} Mode4{CharImp=Zpi}} PhaseDelay=UseScanAngle Phi=0deg Theta=theta_inc LatticeAVector{(-0.16, -0.16, 1.03) -> (0.16, -0.16, 1.03)} LatticeBVector{(-0.16, -0.16, 1.03) -> (-0.16, 0.16, 1.03)} ModesCalculator{Frequency=1GHz PhiStart=0deg PhiStop=0deg PhiStep=0deg ThetaStart=0deg ThetaStop=0deg ThetaStep=0deg} ModesList{Mode{ModeNumber=1 IndexM=0 IndexN=0 KC2=0 PropagationState=Undefined Attenuation=0 PolarizationState=TE AffectsRefinement} Mode{ModeNumber=2 IndexM=0 IndexN=0 KC2=0 PropagationState=Undefined Attenuation=0 PolarizationState=TM AffectsRefinement} Mode{ModeNumber=3 IndexM=-1 IndexN=0 KC2=385531421917553 PropagationState=Undefined Attenuation=1.7054704e+08 PolarizationState=TE AffectsRefinement} Mode{ModeNumber=4 IndexM=0 IndexN=-1 KC2=385531421917553 PropagationState=Undefined Attenuation=1.7054704e+08 PolarizationState=TE AffectsRefinement}}
  FloquetBaixo: Floquet Port Faces=Air_Domain.face(-z) NumModes=4 Modes{Mode1{CharImp=Zpi} Mode2{CharImp=Zpi} Mode3{CharImp=Zpi} Mode4{CharImp=Zpi}} PhaseDelay=UseScanAngle Phi=0deg Theta=theta_inc LatticeAVector{(-0.16, -0.16, -1) -> (0.16, -0.16, -1)} LatticeBVector{(-0.16, -0.16, -1) -> (-0.16, 0.16, -1)} ModesCalculator{Frequency=1GHz PhiStart=0deg PhiStop=0deg PhiStep=0deg ThetaStart=0deg ThetaStop=0deg ThetaStep=0deg} ModesList{Mode{ModeNumber=1 IndexM=0 IndexN=0 KC2=0 PropagationState=Undefined Attenuation=0 PolarizationState=TE AffectsRefinement} Mode{ModeNumber=2 IndexM=0 IndexN=0 KC2=0 PropagationState=Undefined Attenuation=0 PolarizationState=TM AffectsRefinement} Mode{ModeNumber=3 IndexM=-1 IndexN=0 KC2=385531421917553 PropagationState=Undefined Attenuation=1.7054704e+08 PolarizationState=TE AffectsRefinement} Mode{ModeNumber=4 IndexM=0 IndexN=-1 KC2=385531421917553 PropagationState=Undefined Attenuation=1.7054704e+08 PolarizationState=TE AffectsRefinement}}
setups:
  Setup1: HfssDriven Frequency=666.2THz MaxDeltaS=0.01 MaximumPasses=15 MinimumPasses=1 MinimumConvergedPasses=1 PercentRefinement=30 BasisOrder=1 PortAccuracy=2 DrivenSolverType="Direct Solver"
    sweep Varredura: 187.4THz to 666.2THz, 401 points; Type=Interpolating InterpTolerance=0.5 InterpMaxSolns=250 PassivityErrorTolerance=0.0001
source amplitudes:
  FloquetCima:1: 1W 0deg
  FloquetCima:2, FloquetCima:3, FloquetCima:4, FloquetBaixo:1..FloquetBaixo:4: 0W 0deg

design G1143_anelQ_disco_trilhas (HFSS, HFSS Modal Network, model units um)
variables:
  theta_inc = 0deg
geometry:
  Au_anelq [Au_JC] = box(corner=(-0.092um, -0.092um, 0um), size=(0.184um, 0.184um, 0.03um))
  Au_anelq_furo = box(corner=(-0.058um, -0.058um, 0um), size=(0.116um, 0.116um, 0.03um))
  Au_anelq.subtract(Au_anelq_furo)
  Au_disco = cylinder(axis=Z, base_centre=(0um, 0um, 0um), radius=0.043um, height=0.03um)
  Au_trilha0 = box(corner=(0.033um, -0.0145um, 0um), size=(0.042um, 0.029um, 0.03um))
  Au_trilha1 = box(corner=(-0.075um, -0.0145um, 0um), size=(0.042um, 0.029um, 0.03um))
  Au_trilha2 = box(corner=(-0.0145um, 0.033um, 0um), size=(0.029um, 0.042um, 0.03um))
  Au_trilha3 = box(corner=(-0.0145um, -0.075um, 0um), size=(0.029um, 0.042um, 0.03um))
  Au_anelq.unite(Au_disco, Au_trilha0..Au_trilha3)
  Air_Domain [vacuum] = box(corner=(-0.16um, -0.16um, -1um), size=(0.32um, 0.32um, 2.03um))
  Au_anelq_1 = Au_anelq.copy()
  Air_Domain.subtract(Au_anelq_1)
boundaries and excitations:
  LatticePair_AAGEAG: Lattice Pair Faces=Air_Domain.face(-x, +x) CoordSysVector{(-0.16, -0.16, -1) -> (-0.16, -0.16, 1.03)} PhaseDelay=UseScanAngle Phi=0deg Theta=theta_inc
  LatticePair_UA5TL0: Lattice Pair Faces=Air_Domain.face(-y, +y) CoordSysVector{(0.16, -0.16, -1) -> (0.16, -0.16, 1.03)} PhaseDelay=UseScanAngle Phi=0deg Theta=theta_inc
  FloquetCima: Floquet Port Faces=Air_Domain.face(+z) NumModes=4 Modes{Mode1{CharImp=Zpi} Mode2{CharImp=Zpi} Mode3{CharImp=Zpi} Mode4{CharImp=Zpi}} PhaseDelay=UseScanAngle Phi=0deg Theta=theta_inc LatticeAVector{(-0.16, -0.16, 1.03) -> (0.16, -0.16, 1.03)} LatticeBVector{(-0.16, -0.16, 1.03) -> (-0.16, 0.16, 1.03)} ModesCalculator{Frequency=1GHz PhiStart=0deg PhiStop=0deg PhiStep=0deg ThetaStart=0deg ThetaStop=0deg ThetaStep=0deg} ModesList{Mode{ModeNumber=1 IndexM=0 IndexN=0 KC2=0 PropagationState=Undefined Attenuation=0 PolarizationState=TE AffectsRefinement} Mode{ModeNumber=2 IndexM=0 IndexN=0 KC2=0 PropagationState=Undefined Attenuation=0 PolarizationState=TM AffectsRefinement} Mode{ModeNumber=3 IndexM=-1 IndexN=0 KC2=385531421917553 PropagationState=Undefined Attenuation=1.7054704e+08 PolarizationState=TE AffectsRefinement} Mode{ModeNumber=4 IndexM=0 IndexN=-1 KC2=385531421917553 PropagationState=Undefined Attenuation=1.7054704e+08 PolarizationState=TE AffectsRefinement}}
  FloquetBaixo: Floquet Port Faces=Air_Domain.face(-z) NumModes=4 Modes{Mode1{CharImp=Zpi} Mode2{CharImp=Zpi} Mode3{CharImp=Zpi} Mode4{CharImp=Zpi}} PhaseDelay=UseScanAngle Phi=0deg Theta=theta_inc LatticeAVector{(-0.16, -0.16, -1) -> (0.16, -0.16, -1)} LatticeBVector{(-0.16, -0.16, -1) -> (-0.16, 0.16, -1)} ModesCalculator{Frequency=1GHz PhiStart=0deg PhiStop=0deg PhiStep=0deg ThetaStart=0deg ThetaStop=0deg ThetaStep=0deg} ModesList{Mode{ModeNumber=1 IndexM=0 IndexN=0 KC2=0 PropagationState=Undefined Attenuation=0 PolarizationState=TE AffectsRefinement} Mode{ModeNumber=2 IndexM=0 IndexN=0 KC2=0 PropagationState=Undefined Attenuation=0 PolarizationState=TM AffectsRefinement} Mode{ModeNumber=3 IndexM=-1 IndexN=0 KC2=385531421917553 PropagationState=Undefined Attenuation=1.7054704e+08 PolarizationState=TE AffectsRefinement} Mode{ModeNumber=4 IndexM=0 IndexN=-1 KC2=385531421917553 PropagationState=Undefined Attenuation=1.7054704e+08 PolarizationState=TE AffectsRefinement}}
setups:
  Setup1: HfssDriven Frequency=666.2THz MaxDeltaS=0.01 MaximumPasses=15 MinimumPasses=1 MinimumConvergedPasses=1 PercentRefinement=30 BasisOrder=1 PortAccuracy=2 DrivenSolverType="Direct Solver"
    sweep Varredura: 187.4THz to 666.2THz, 401 points; Type=Interpolating InterpTolerance=0.5 InterpMaxSolns=250 PassivityErrorTolerance=0.0001
source amplitudes:
  FloquetCima:1: 1W 0deg
  FloquetCima:2, FloquetCima:3, FloquetCima:4, FloquetBaixo:1..FloquetBaixo:4: 0W 0deg

design G1141_anelQ_disco_trilhas (HFSS, HFSS Modal Network, model units um)
variables:
  theta_inc = 0deg
geometry:
  Au_anelq [Au_JC] = box(corner=(-0.108um, -0.108um, 0um), size=(0.216um, 0.216um, 0.03um))
  Au_anelq_furo = box(corner=(-0.077um, -0.077um, 0um), size=(0.154um, 0.154um, 0.03um))
  Au_anelq.subtract(Au_anelq_furo)
  Au_disco = cylinder(axis=Z, base_centre=(0um, 0um, 0um), radius=0.043um, height=0.03um)
  Au_trilha0 = box(corner=(0.033um, -0.0125um, 0um), size=(0.0595um, 0.025um, 0.03um))
  Au_trilha1 = box(corner=(-0.0925um, -0.0125um, 0um), size=(0.0595um, 0.025um, 0.03um))
  Au_trilha2 = box(corner=(-0.0125um, 0.033um, 0um), size=(0.025um, 0.0595um, 0.03um))
  Au_trilha3 = box(corner=(-0.0125um, -0.0925um, 0um), size=(0.025um, 0.0595um, 0.03um))
  Au_anelq.unite(Au_disco, Au_trilha0..Au_trilha3)
  Air_Domain [vacuum] = box(corner=(-0.16um, -0.16um, -1um), size=(0.32um, 0.32um, 2.03um))
  Au_anelq_1 = Au_anelq.copy()
  Air_Domain.subtract(Au_anelq_1)
boundaries and excitations:
  LatticePair_10TTUV: Lattice Pair Faces=Air_Domain.face(-x, +x) CoordSysVector{(-0.16, -0.16, -1) -> (-0.16, -0.16, 1.03)} PhaseDelay=UseScanAngle Phi=0deg Theta=theta_inc
  LatticePair_7HKC2F: Lattice Pair Faces=Air_Domain.face(-y, +y) CoordSysVector{(0.16, -0.16, -1) -> (0.16, -0.16, 1.03)} PhaseDelay=UseScanAngle Phi=0deg Theta=theta_inc
  FloquetCima: Floquet Port Faces=Air_Domain.face(+z) NumModes=4 Modes{Mode1{CharImp=Zpi} Mode2{CharImp=Zpi} Mode3{CharImp=Zpi} Mode4{CharImp=Zpi}} PhaseDelay=UseScanAngle Phi=0deg Theta=theta_inc LatticeAVector{(-0.16, -0.16, 1.03) -> (0.16, -0.16, 1.03)} LatticeBVector{(-0.16, -0.16, 1.03) -> (-0.16, 0.16, 1.03)} ModesCalculator{Frequency=1GHz PhiStart=0deg PhiStop=0deg PhiStep=0deg ThetaStart=0deg ThetaStop=0deg ThetaStep=0deg} ModesList{Mode{ModeNumber=1 IndexM=0 IndexN=0 KC2=0 PropagationState=Undefined Attenuation=0 PolarizationState=TE AffectsRefinement} Mode{ModeNumber=2 IndexM=0 IndexN=0 KC2=0 PropagationState=Undefined Attenuation=0 PolarizationState=TM AffectsRefinement} Mode{ModeNumber=3 IndexM=-1 IndexN=0 KC2=385531421917553 PropagationState=Undefined Attenuation=1.7054704e+08 PolarizationState=TE AffectsRefinement} Mode{ModeNumber=4 IndexM=0 IndexN=-1 KC2=385531421917553 PropagationState=Undefined Attenuation=1.7054704e+08 PolarizationState=TE AffectsRefinement}}
  FloquetBaixo: Floquet Port Faces=Air_Domain.face(-z) NumModes=4 Modes{Mode1{CharImp=Zpi} Mode2{CharImp=Zpi} Mode3{CharImp=Zpi} Mode4{CharImp=Zpi}} PhaseDelay=UseScanAngle Phi=0deg Theta=theta_inc LatticeAVector{(-0.16, -0.16, -1) -> (0.16, -0.16, -1)} LatticeBVector{(-0.16, -0.16, -1) -> (-0.16, 0.16, -1)} ModesCalculator{Frequency=1GHz PhiStart=0deg PhiStop=0deg PhiStep=0deg ThetaStart=0deg ThetaStop=0deg ThetaStep=0deg} ModesList{Mode{ModeNumber=1 IndexM=0 IndexN=0 KC2=0 PropagationState=Undefined Attenuation=0 PolarizationState=TE AffectsRefinement} Mode{ModeNumber=2 IndexM=0 IndexN=0 KC2=0 PropagationState=Undefined Attenuation=0 PolarizationState=TM AffectsRefinement} Mode{ModeNumber=3 IndexM=-1 IndexN=0 KC2=385531421917553 PropagationState=Undefined Attenuation=1.7054704e+08 PolarizationState=TE AffectsRefinement} Mode{ModeNumber=4 IndexM=0 IndexN=-1 KC2=385531421917553 PropagationState=Undefined Attenuation=1.7054704e+08 PolarizationState=TE AffectsRefinement}}
setups:
  Setup1: HfssDriven Frequency=666.2THz MaxDeltaS=0.01 MaximumPasses=15 MinimumPasses=1 MinimumConvergedPasses=1 PercentRefinement=30 BasisOrder=1 PortAccuracy=2 DrivenSolverType="Direct Solver"
    sweep Varredura: 187.4THz to 666.2THz, 401 points; Type=Interpolating InterpTolerance=0.5 InterpMaxSolns=250 PassivityErrorTolerance=0.0001
source amplitudes:
  FloquetCima:1: 1W 0deg
  FloquetCima:2, FloquetCima:3, FloquetCima:4, FloquetBaixo:1..FloquetBaixo:4: 0W 0deg

design G1108_anelQ_disco_trilhas (HFSS, HFSS Modal Network, model units um)
variables:
  theta_inc = 0deg
geometry:
  Au_anelq [Au_JC] = box(corner=(-0.0975um, -0.0975um, 0um), size=(0.195um, 0.195um, 0.03um))
  Au_anelq_furo = box(corner=(-0.0535um, -0.0535um, 0um), size=(0.107um, 0.107um, 0.03um))
  Au_anelq.subtract(Au_anelq_furo)
  Au_disco = cylinder(axis=Z, base_centre=(0um, 0um, 0um), radius=0.027um, height=0.03um)
  Au_trilha0 = box(corner=(0.017um, -0.0145um, 0um), size=(0.0585um, 0.029um, 0.03um))
  Au_trilha1 = box(corner=(-0.0755um, -0.0145um, 0um), size=(0.0585um, 0.029um, 0.03um))
  Au_trilha2 = box(corner=(-0.0145um, 0.017um, 0um), size=(0.029um, 0.0585um, 0.03um))
  Au_trilha3 = box(corner=(-0.0145um, -0.0755um, 0um), size=(0.029um, 0.0585um, 0.03um))
  Au_anelq.unite(Au_disco, Au_trilha0..Au_trilha3)
  Air_Domain [vacuum] = box(corner=(-0.16um, -0.16um, -1um), size=(0.32um, 0.32um, 2.03um))
  Au_anelq_1 = Au_anelq.copy()
  Air_Domain.subtract(Au_anelq_1)
boundaries and excitations:
  LatticePair_WZNFRN: Lattice Pair Faces=Air_Domain.face(-x, +x) CoordSysVector{(-0.16, -0.16, -1) -> (-0.16, -0.16, 1.03)} PhaseDelay=UseScanAngle Phi=0deg Theta=theta_inc
  LatticePair_H2Y62M: Lattice Pair Faces=Air_Domain.face(-y, +y) CoordSysVector{(0.16, -0.16, -1) -> (0.16, -0.16, 1.03)} PhaseDelay=UseScanAngle Phi=0deg Theta=theta_inc
  FloquetCima: Floquet Port Faces=Air_Domain.face(+z) NumModes=4 Modes{Mode1{CharImp=Zpi} Mode2{CharImp=Zpi} Mode3{CharImp=Zpi} Mode4{CharImp=Zpi}} PhaseDelay=UseScanAngle Phi=0deg Theta=theta_inc LatticeAVector{(-0.16, -0.16, 1.03) -> (0.16, -0.16, 1.03)} LatticeBVector{(-0.16, -0.16, 1.03) -> (-0.16, 0.16, 1.03)} ModesCalculator{Frequency=1GHz PhiStart=0deg PhiStop=0deg PhiStep=0deg ThetaStart=0deg ThetaStop=0deg ThetaStep=0deg} ModesList{Mode{ModeNumber=1 IndexM=0 IndexN=0 KC2=0 PropagationState=Undefined Attenuation=0 PolarizationState=TE AffectsRefinement} Mode{ModeNumber=2 IndexM=0 IndexN=0 KC2=0 PropagationState=Undefined Attenuation=0 PolarizationState=TM AffectsRefinement} Mode{ModeNumber=3 IndexM=-1 IndexN=0 KC2=385531421917553 PropagationState=Undefined Attenuation=1.7054704e+08 PolarizationState=TE AffectsRefinement} Mode{ModeNumber=4 IndexM=0 IndexN=-1 KC2=385531421917553 PropagationState=Undefined Attenuation=1.7054704e+08 PolarizationState=TE AffectsRefinement}}
  FloquetBaixo: Floquet Port Faces=Air_Domain.face(-z) NumModes=4 Modes{Mode1{CharImp=Zpi} Mode2{CharImp=Zpi} Mode3{CharImp=Zpi} Mode4{CharImp=Zpi}} PhaseDelay=UseScanAngle Phi=0deg Theta=theta_inc LatticeAVector{(-0.16, -0.16, -1) -> (0.16, -0.16, -1)} LatticeBVector{(-0.16, -0.16, -1) -> (-0.16, 0.16, -1)} ModesCalculator{Frequency=1GHz PhiStart=0deg PhiStop=0deg PhiStep=0deg ThetaStart=0deg ThetaStop=0deg ThetaStep=0deg} ModesList{Mode{ModeNumber=1 IndexM=0 IndexN=0 KC2=0 PropagationState=Undefined Attenuation=0 PolarizationState=TE AffectsRefinement} Mode{ModeNumber=2 IndexM=0 IndexN=0 KC2=0 PropagationState=Undefined Attenuation=0 PolarizationState=TM AffectsRefinement} Mode{ModeNumber=3 IndexM=-1 IndexN=0 KC2=385531421917553 PropagationState=Undefined Attenuation=1.7054704e+08 PolarizationState=TE AffectsRefinement} Mode{ModeNumber=4 IndexM=0 IndexN=-1 KC2=385531421917553 PropagationState=Undefined Attenuation=1.7054704e+08 PolarizationState=TE AffectsRefinement}}
setups:
  Setup1: HfssDriven Frequency=666.2THz MaxDeltaS=0.01 MaximumPasses=15 MinimumPasses=1 MinimumConvergedPasses=1 PercentRefinement=30 BasisOrder=1 PortAccuracy=2 DrivenSolverType="Direct Solver"
    sweep Varredura: 187.4THz to 666.2THz, 401 points; Type=Interpolating InterpTolerance=0.5 InterpMaxSolns=250 PassivityErrorTolerance=0.0001
source amplitudes:
  FloquetCima:1: 1W 0deg
  FloquetCima:2, FloquetCima:3, FloquetCima:4, FloquetBaixo:1..FloquetBaixo:4: 0W 0deg

design G1191_anelQ_disco_trilhas (HFSS, HFSS Modal Network, model units um)
variables:
  theta_inc = 0deg
geometry:
  Au_anelq [Au_JC] = box(corner=(-0.103um, -0.103um, 0um), size=(0.206um, 0.206um, 0.03um))
  Au_anelq_furo = box(corner=(-0.074um, -0.074um, 0um), size=(0.148um, 0.148um, 0.03um))
  Au_anelq.subtract(Au_anelq_furo)
  Au_disco = cylinder(axis=Z, base_centre=(0um, 0um, 0um), radius=0.036um, height=0.03um)
  Au_trilha0 = box(corner=(0.026um, -0.0125um, 0um), size=(0.0625um, 0.025um, 0.03um))
  Au_trilha1 = box(corner=(-0.0885um, -0.0125um, 0um), size=(0.0625um, 0.025um, 0.03um))
  Au_trilha2 = box(corner=(-0.0125um, 0.026um, 0um), size=(0.025um, 0.0625um, 0.03um))
  Au_trilha3 = box(corner=(-0.0125um, -0.0885um, 0um), size=(0.025um, 0.0625um, 0.03um))
  Au_anelq.unite(Au_disco, Au_trilha0..Au_trilha3)
  Air_Domain [vacuum] = box(corner=(-0.16um, -0.16um, -1um), size=(0.32um, 0.32um, 2.03um))
  Au_anelq_1 = Au_anelq.copy()
  Air_Domain.subtract(Au_anelq_1)
boundaries and excitations:
  LatticePair_WSG8L6: Lattice Pair Faces=Air_Domain.face(-x, +x) CoordSysVector{(-0.16, -0.16, -1) -> (-0.16, -0.16, 1.03)} PhaseDelay=UseScanAngle Phi=0deg Theta=theta_inc
  LatticePair_U282T6: Lattice Pair Faces=Air_Domain.face(-y, +y) CoordSysVector{(0.16, -0.16, -1) -> (0.16, -0.16, 1.03)} PhaseDelay=UseScanAngle Phi=0deg Theta=theta_inc
  FloquetCima: Floquet Port Faces=Air_Domain.face(+z) NumModes=4 Modes{Mode1{CharImp=Zpi} Mode2{CharImp=Zpi} Mode3{CharImp=Zpi} Mode4{CharImp=Zpi}} PhaseDelay=UseScanAngle Phi=0deg Theta=theta_inc LatticeAVector{(-0.16, -0.16, 1.03) -> (0.16, -0.16, 1.03)} LatticeBVector{(-0.16, -0.16, 1.03) -> (-0.16, 0.16, 1.03)} ModesCalculator{Frequency=1GHz PhiStart=0deg PhiStop=0deg PhiStep=0deg ThetaStart=0deg ThetaStop=0deg ThetaStep=0deg} ModesList{Mode{ModeNumber=1 IndexM=0 IndexN=0 KC2=0 PropagationState=Undefined Attenuation=0 PolarizationState=TE AffectsRefinement} Mode{ModeNumber=2 IndexM=0 IndexN=0 KC2=0 PropagationState=Undefined Attenuation=0 PolarizationState=TM AffectsRefinement} Mode{ModeNumber=3 IndexM=-1 IndexN=0 KC2=385531421917553 PropagationState=Undefined Attenuation=1.7054704e+08 PolarizationState=TE AffectsRefinement} Mode{ModeNumber=4 IndexM=0 IndexN=-1 KC2=385531421917553 PropagationState=Undefined Attenuation=1.7054704e+08 PolarizationState=TE AffectsRefinement}}
  FloquetBaixo: Floquet Port Faces=Air_Domain.face(-z) NumModes=4 Modes{Mode1{CharImp=Zpi} Mode2{CharImp=Zpi} Mode3{CharImp=Zpi} Mode4{CharImp=Zpi}} PhaseDelay=UseScanAngle Phi=0deg Theta=theta_inc LatticeAVector{(-0.16, -0.16, -1) -> (0.16, -0.16, -1)} LatticeBVector{(-0.16, -0.16, -1) -> (-0.16, 0.16, -1)} ModesCalculator{Frequency=1GHz PhiStart=0deg PhiStop=0deg PhiStep=0deg ThetaStart=0deg ThetaStop=0deg ThetaStep=0deg} ModesList{Mode{ModeNumber=1 IndexM=0 IndexN=0 KC2=0 PropagationState=Undefined Attenuation=0 PolarizationState=TE AffectsRefinement} Mode{ModeNumber=2 IndexM=0 IndexN=0 KC2=0 PropagationState=Undefined Attenuation=0 PolarizationState=TM AffectsRefinement} Mode{ModeNumber=3 IndexM=-1 IndexN=0 KC2=385531421917553 PropagationState=Undefined Attenuation=1.7054704e+08 PolarizationState=TE AffectsRefinement} Mode{ModeNumber=4 IndexM=0 IndexN=-1 KC2=385531421917553 PropagationState=Undefined Attenuation=1.7054704e+08 PolarizationState=TE AffectsRefinement}}
setups:
  Setup1: HfssDriven Frequency=666.2THz MaxDeltaS=0.01 MaximumPasses=15 MinimumPasses=1 MinimumConvergedPasses=1 PercentRefinement=30 BasisOrder=1 PortAccuracy=2 DrivenSolverType="Direct Solver"
    sweep Varredura: 187.4THz to 666.2THz, 401 points; Type=Interpolating InterpTolerance=0.5 InterpMaxSolns=250 PassivityErrorTolerance=0.0001
source amplitudes:
  FloquetCima:1: 1W 0deg
  FloquetCima:2, FloquetCima:3, FloquetCima:4, FloquetBaixo:1..FloquetBaixo:4: 0W 0deg

design G1054_anelQ_disco_trilhas (HFSS, HFSS Modal Network, model units um)
variables:
  theta_inc = 0deg
geometry:
  Au_anelq [Au_JC] = box(corner=(-0.084um, -0.084um, 0um), size=(0.168um, 0.168um, 0.03um))
  Au_anelq_furo = box(corner=(-0.041um, -0.041um, 0um), size=(0.082um, 0.082um, 0.03um))
  Au_anelq.subtract(Au_anelq_furo)
  Au_disco = cylinder(axis=Z, base_centre=(0um, 0um, 0um), radius=0.027um, height=0.03um)
  Au_trilha0 = box(corner=(0.017um, -0.0105um, 0um), size=(0.0455um, 0.021um, 0.03um))
  Au_trilha1 = box(corner=(-0.0625um, -0.0105um, 0um), size=(0.0455um, 0.021um, 0.03um))
  Au_trilha2 = box(corner=(-0.0105um, 0.017um, 0um), size=(0.021um, 0.0455um, 0.03um))
  Au_trilha3 = box(corner=(-0.0105um, -0.0625um, 0um), size=(0.021um, 0.0455um, 0.03um))
  Au_anelq.unite(Au_disco, Au_trilha0..Au_trilha3)
  Air_Domain [vacuum] = box(corner=(-0.16um, -0.16um, -1um), size=(0.32um, 0.32um, 2.03um))
  Au_anelq_1 = Au_anelq.copy()
  Air_Domain.subtract(Au_anelq_1)
boundaries and excitations:
  LatticePair_X6FLCN: Lattice Pair Faces=Air_Domain.face(-x, +x) CoordSysVector{(-0.16, -0.16, -1) -> (-0.16, -0.16, 1.03)} PhaseDelay=UseScanAngle Phi=0deg Theta=theta_inc
  LatticePair_3XZZ7G: Lattice Pair Faces=Air_Domain.face(-y, +y) CoordSysVector{(0.16, -0.16, -1) -> (0.16, -0.16, 1.03)} PhaseDelay=UseScanAngle Phi=0deg Theta=theta_inc
  FloquetCima: Floquet Port Faces=Air_Domain.face(+z) NumModes=4 Modes{Mode1{CharImp=Zpi} Mode2{CharImp=Zpi} Mode3{CharImp=Zpi} Mode4{CharImp=Zpi}} PhaseDelay=UseScanAngle Phi=0deg Theta=theta_inc LatticeAVector{(-0.16, -0.16, 1.03) -> (0.16, -0.16, 1.03)} LatticeBVector{(-0.16, -0.16, 1.03) -> (-0.16, 0.16, 1.03)} ModesCalculator{Frequency=1GHz PhiStart=0deg PhiStop=0deg PhiStep=0deg ThetaStart=0deg ThetaStop=0deg ThetaStep=0deg} ModesList{Mode{ModeNumber=1 IndexM=0 IndexN=0 KC2=0 PropagationState=Undefined Attenuation=0 PolarizationState=TE AffectsRefinement} Mode{ModeNumber=2 IndexM=0 IndexN=0 KC2=0 PropagationState=Undefined Attenuation=0 PolarizationState=TM AffectsRefinement} Mode{ModeNumber=3 IndexM=-1 IndexN=0 KC2=385531421917553 PropagationState=Undefined Attenuation=1.7054704e+08 PolarizationState=TE AffectsRefinement} Mode{ModeNumber=4 IndexM=0 IndexN=-1 KC2=385531421917553 PropagationState=Undefined Attenuation=1.7054704e+08 PolarizationState=TE AffectsRefinement}}
  FloquetBaixo: Floquet Port Faces=Air_Domain.face(-z) NumModes=4 Modes{Mode1{CharImp=Zpi} Mode2{CharImp=Zpi} Mode3{CharImp=Zpi} Mode4{CharImp=Zpi}} PhaseDelay=UseScanAngle Phi=0deg Theta=theta_inc LatticeAVector{(-0.16, -0.16, -1) -> (0.16, -0.16, -1)} LatticeBVector{(-0.16, -0.16, -1) -> (-0.16, 0.16, -1)} ModesCalculator{Frequency=1GHz PhiStart=0deg PhiStop=0deg PhiStep=0deg ThetaStart=0deg ThetaStop=0deg ThetaStep=0deg} ModesList{Mode{ModeNumber=1 IndexM=0 IndexN=0 KC2=0 PropagationState=Undefined Attenuation=0 PolarizationState=TE AffectsRefinement} Mode{ModeNumber=2 IndexM=0 IndexN=0 KC2=0 PropagationState=Undefined Attenuation=0 PolarizationState=TM AffectsRefinement} Mode{ModeNumber=3 IndexM=-1 IndexN=0 KC2=385531421917553 PropagationState=Undefined Attenuation=1.7054704e+08 PolarizationState=TE AffectsRefinement} Mode{ModeNumber=4 IndexM=0 IndexN=-1 KC2=385531421917553 PropagationState=Undefined Attenuation=1.7054704e+08 PolarizationState=TE AffectsRefinement}}
setups:
  Setup1: HfssDriven Frequency=666.2THz MaxDeltaS=0.01 MaximumPasses=15 MinimumPasses=1 MinimumConvergedPasses=1 PercentRefinement=30 BasisOrder=1 PortAccuracy=2 DrivenSolverType="Direct Solver"
    sweep Varredura: 187.4THz to 666.2THz, 401 points; Type=Interpolating InterpTolerance=0.5 InterpMaxSolns=250 PassivityErrorTolerance=0.0001
source amplitudes:
  FloquetCima:1: 1W 0deg
  FloquetCima:2, FloquetCima:3, FloquetCima:4, FloquetBaixo:1..FloquetBaixo:4: 0W 0deg

design G1239_anelQ_quadrado (HFSS, HFSS Modal Network, model units um)
variables:
  theta_inc = 0deg
geometry:
  Au_anelq [Au_JC] = box(corner=(-0.097um, -0.097um, 0um), size=(0.194um, 0.194um, 0.03um))
  Au_anelq_furo = box(corner=(-0.049um, -0.049um, 0um), size=(0.098um, 0.098um, 0.03um))
  Au_anelq.subtract(Au_anelq_furo)
  Au_quadrado = box(corner=(-0.024um, -0.024um, 0um), size=(0.048um, 0.048um, 0.03um))
  Au_anelq.unite(Au_quadrado)
  Air_Domain [vacuum] = box(corner=(-0.16um, -0.16um, -1um), size=(0.32um, 0.32um, 2.03um))
  Au_anelq_1 = Au_anelq.copy()
  Air_Domain.subtract(Au_anelq_1)
boundaries and excitations:
  LatticePair_FUVEFG: Lattice Pair Faces=Air_Domain.face(-x, +x) CoordSysVector{(-0.16, -0.16, -1) -> (-0.16, -0.16, 1.03)} PhaseDelay=UseScanAngle Phi=0deg Theta=theta_inc
  LatticePair_RV0S04: Lattice Pair Faces=Air_Domain.face(-y, +y) CoordSysVector{(0.16, -0.16, -1) -> (0.16, -0.16, 1.03)} PhaseDelay=UseScanAngle Phi=0deg Theta=theta_inc
  FloquetCima: Floquet Port Faces=Air_Domain.face(+z) NumModes=4 Modes{Mode1{CharImp=Zpi} Mode2{CharImp=Zpi} Mode3{CharImp=Zpi} Mode4{CharImp=Zpi}} PhaseDelay=UseScanAngle Phi=0deg Theta=theta_inc LatticeAVector{(-0.16, -0.16, 1.03) -> (0.16, -0.16, 1.03)} LatticeBVector{(-0.16, -0.16, 1.03) -> (-0.16, 0.16, 1.03)} ModesCalculator{Frequency=1GHz PhiStart=0deg PhiStop=0deg PhiStep=0deg ThetaStart=0deg ThetaStop=0deg ThetaStep=0deg} ModesList{Mode{ModeNumber=1 IndexM=0 IndexN=0 KC2=0 PropagationState=Undefined Attenuation=0 PolarizationState=TE AffectsRefinement} Mode{ModeNumber=2 IndexM=0 IndexN=0 KC2=0 PropagationState=Undefined Attenuation=0 PolarizationState=TM AffectsRefinement} Mode{ModeNumber=3 IndexM=-1 IndexN=0 KC2=385531421917553 PropagationState=Undefined Attenuation=1.7054704e+08 PolarizationState=TE AffectsRefinement} Mode{ModeNumber=4 IndexM=0 IndexN=-1 KC2=385531421917553 PropagationState=Undefined Attenuation=1.7054704e+08 PolarizationState=TE AffectsRefinement}}
  FloquetBaixo: Floquet Port Faces=Air_Domain.face(-z) NumModes=4 Modes{Mode1{CharImp=Zpi} Mode2{CharImp=Zpi} Mode3{CharImp=Zpi} Mode4{CharImp=Zpi}} PhaseDelay=UseScanAngle Phi=0deg Theta=theta_inc LatticeAVector{(-0.16, -0.16, -1) -> (0.16, -0.16, -1)} LatticeBVector{(-0.16, -0.16, -1) -> (-0.16, 0.16, -1)} ModesCalculator{Frequency=1GHz PhiStart=0deg PhiStop=0deg PhiStep=0deg ThetaStart=0deg ThetaStop=0deg ThetaStep=0deg} ModesList{Mode{ModeNumber=1 IndexM=0 IndexN=0 KC2=0 PropagationState=Undefined Attenuation=0 PolarizationState=TE AffectsRefinement} Mode{ModeNumber=2 IndexM=0 IndexN=0 KC2=0 PropagationState=Undefined Attenuation=0 PolarizationState=TM AffectsRefinement} Mode{ModeNumber=3 IndexM=-1 IndexN=0 KC2=385531421917553 PropagationState=Undefined Attenuation=1.7054704e+08 PolarizationState=TE AffectsRefinement} Mode{ModeNumber=4 IndexM=0 IndexN=-1 KC2=385531421917553 PropagationState=Undefined Attenuation=1.7054704e+08 PolarizationState=TE AffectsRefinement}}
setups:
  Setup1: HfssDriven Frequency=666.2THz MaxDeltaS=0.01 MaximumPasses=15 MinimumPasses=1 MinimumConvergedPasses=1 PercentRefinement=30 BasisOrder=1 PortAccuracy=2 DrivenSolverType="Direct Solver"
    sweep Varredura: 187.4THz to 666.2THz, 401 points; Type=Interpolating InterpTolerance=0.5 InterpMaxSolns=250 PassivityErrorTolerance=0.0001
source amplitudes:
  FloquetCima:1: 1W 0deg
  FloquetCima:2, FloquetCima:3, FloquetCima:4, FloquetBaixo:1..FloquetBaixo:4: 0W 0deg

design G1270_anelQ_quadrado (HFSS, HFSS Modal Network, model units um)
variables:
  theta_inc = 0deg
geometry:
  Au_anelq [Au_JC] = box(corner=(-0.0975um, -0.0975um, 0um), size=(0.195um, 0.195um, 0.03um))
  Au_anelq_furo = box(corner=(-0.0605um, -0.0605um, 0um), size=(0.121um, 0.121um, 0.03um))
  Au_anelq.subtract(Au_anelq_furo)
  Au_quadrado = box(corner=(-0.0335um, -0.0335um, 0um), size=(0.067um, 0.067um, 0.03um))
  Au_anelq.unite(Au_quadrado)
  Air_Domain [vacuum] = box(corner=(-0.16um, -0.16um, -1um), size=(0.32um, 0.32um, 2.03um))
  Au_anelq_1 = Au_anelq.copy()
  Air_Domain.subtract(Au_anelq_1)
boundaries and excitations:
  LatticePair_X7DLZ6: Lattice Pair Faces=Air_Domain.face(-x, +x) CoordSysVector{(-0.16, -0.16, -1) -> (-0.16, -0.16, 1.03)} PhaseDelay=UseScanAngle Phi=0deg Theta=theta_inc
  LatticePair_GGUBDY: Lattice Pair Faces=Air_Domain.face(-y, +y) CoordSysVector{(0.16, -0.16, -1) -> (0.16, -0.16, 1.03)} PhaseDelay=UseScanAngle Phi=0deg Theta=theta_inc
  FloquetCima: Floquet Port Faces=Air_Domain.face(+z) NumModes=4 Modes{Mode1{CharImp=Zpi} Mode2{CharImp=Zpi} Mode3{CharImp=Zpi} Mode4{CharImp=Zpi}} PhaseDelay=UseScanAngle Phi=0deg Theta=theta_inc LatticeAVector{(-0.16, -0.16, 1.03) -> (0.16, -0.16, 1.03)} LatticeBVector{(-0.16, -0.16, 1.03) -> (-0.16, 0.16, 1.03)} ModesCalculator{Frequency=1GHz PhiStart=0deg PhiStop=0deg PhiStep=0deg ThetaStart=0deg ThetaStop=0deg ThetaStep=0deg} ModesList{Mode{ModeNumber=1 IndexM=0 IndexN=0 KC2=0 PropagationState=Undefined Attenuation=0 PolarizationState=TE AffectsRefinement} Mode{ModeNumber=2 IndexM=0 IndexN=0 KC2=0 PropagationState=Undefined Attenuation=0 PolarizationState=TM AffectsRefinement} Mode{ModeNumber=3 IndexM=-1 IndexN=0 KC2=385531421917553 PropagationState=Undefined Attenuation=1.7054704e+08 PolarizationState=TE AffectsRefinement} Mode{ModeNumber=4 IndexM=0 IndexN=-1 KC2=385531421917553 PropagationState=Undefined Attenuation=1.7054704e+08 PolarizationState=TE AffectsRefinement}}
  FloquetBaixo: Floquet Port Faces=Air_Domain.face(-z) NumModes=4 Modes{Mode1{CharImp=Zpi} Mode2{CharImp=Zpi} Mode3{CharImp=Zpi} Mode4{CharImp=Zpi}} PhaseDelay=UseScanAngle Phi=0deg Theta=theta_inc LatticeAVector{(-0.16, -0.16, -1) -> (0.16, -0.16, -1)} LatticeBVector{(-0.16, -0.16, -1) -> (-0.16, 0.16, -1)} ModesCalculator{Frequency=1GHz PhiStart=0deg PhiStop=0deg PhiStep=0deg ThetaStart=0deg ThetaStop=0deg ThetaStep=0deg} ModesList{Mode{ModeNumber=1 IndexM=0 IndexN=0 KC2=0 PropagationState=Undefined Attenuation=0 PolarizationState=TE AffectsRefinement} Mode{ModeNumber=2 IndexM=0 IndexN=0 KC2=0 PropagationState=Undefined Attenuation=0 PolarizationState=TM AffectsRefinement} Mode{ModeNumber=3 IndexM=-1 IndexN=0 KC2=385531421917553 PropagationState=Undefined Attenuation=1.7054704e+08 PolarizationState=TE AffectsRefinement} Mode{ModeNumber=4 IndexM=0 IndexN=-1 KC2=385531421917553 PropagationState=Undefined Attenuation=1.7054704e+08 PolarizationState=TE AffectsRefinement}}
setups:
  Setup1: HfssDriven Frequency=666.2THz MaxDeltaS=0.01 MaximumPasses=15 MinimumPasses=1 MinimumConvergedPasses=1 PercentRefinement=30 BasisOrder=1 PortAccuracy=2 DrivenSolverType="Direct Solver"
    sweep Varredura: 187.4THz to 666.2THz, 401 points; Type=Interpolating InterpTolerance=0.5 InterpMaxSolns=250 PassivityErrorTolerance=0.0001
source amplitudes:
  FloquetCima:1: 1W 0deg
  FloquetCima:2, FloquetCima:3, FloquetCima:4, FloquetBaixo:1..FloquetBaixo:4: 0W 0deg

design G1331_anelQ_quadrado (HFSS, HFSS Modal Network, model units um)
variables:
  theta_inc = 0deg
geometry:
  Au_anelq [Au_JC] = box(corner=(-0.0905um, -0.0905um, 0um), size=(0.181um, 0.181um, 0.03um))
  Au_anelq_furo = box(corner=(-0.0435um, -0.0435um, 0um), size=(0.087um, 0.087um, 0.03um))
  Au_anelq.subtract(Au_anelq_furo)
  Au_quadrado = box(corner=(-0.0325um, -0.0325um, 0um), size=(0.065um, 0.065um, 0.03um))
  Au_anelq.unite(Au_quadrado)
  Air_Domain [vacuum] = box(corner=(-0.16um, -0.16um, -1um), size=(0.32um, 0.32um, 2.03um))
  Au_anelq_1 = Au_anelq.copy()
  Air_Domain.subtract(Au_anelq_1)
boundaries and excitations:
  LatticePair_J9WFCN: Lattice Pair Faces=Air_Domain.face(-x, +x) CoordSysVector{(-0.16, -0.16, -1) -> (-0.16, -0.16, 1.03)} PhaseDelay=UseScanAngle Phi=0deg Theta=theta_inc
  LatticePair_CKGITH: Lattice Pair Faces=Air_Domain.face(-y, +y) CoordSysVector{(0.16, -0.16, -1) -> (0.16, -0.16, 1.03)} PhaseDelay=UseScanAngle Phi=0deg Theta=theta_inc
  FloquetCima: Floquet Port Faces=Air_Domain.face(+z) NumModes=4 Modes{Mode1{CharImp=Zpi} Mode2{CharImp=Zpi} Mode3{CharImp=Zpi} Mode4{CharImp=Zpi}} PhaseDelay=UseScanAngle Phi=0deg Theta=theta_inc LatticeAVector{(-0.16, -0.16, 1.03) -> (0.16, -0.16, 1.03)} LatticeBVector{(-0.16, -0.16, 1.03) -> (-0.16, 0.16, 1.03)} ModesCalculator{Frequency=1GHz PhiStart=0deg PhiStop=0deg PhiStep=0deg ThetaStart=0deg ThetaStop=0deg ThetaStep=0deg} ModesList{Mode{ModeNumber=1 IndexM=0 IndexN=0 KC2=0 PropagationState=Undefined Attenuation=0 PolarizationState=TE AffectsRefinement} Mode{ModeNumber=2 IndexM=0 IndexN=0 KC2=0 PropagationState=Undefined Attenuation=0 PolarizationState=TM AffectsRefinement} Mode{ModeNumber=3 IndexM=-1 IndexN=0 KC2=385531421917553 PropagationState=Undefined Attenuation=1.7054704e+08 PolarizationState=TE AffectsRefinement} Mode{ModeNumber=4 IndexM=0 IndexN=-1 KC2=385531421917553 PropagationState=Undefined Attenuation=1.7054704e+08 PolarizationState=TE AffectsRefinement}}
  FloquetBaixo: Floquet Port Faces=Air_Domain.face(-z) NumModes=4 Modes{Mode1{CharImp=Zpi} Mode2{CharImp=Zpi} Mode3{CharImp=Zpi} Mode4{CharImp=Zpi}} PhaseDelay=UseScanAngle Phi=0deg Theta=theta_inc LatticeAVector{(-0.16, -0.16, -1) -> (0.16, -0.16, -1)} LatticeBVector{(-0.16, -0.16, -1) -> (-0.16, 0.16, -1)} ModesCalculator{Frequency=1GHz PhiStart=0deg PhiStop=0deg PhiStep=0deg ThetaStart=0deg ThetaStop=0deg ThetaStep=0deg} ModesList{Mode{ModeNumber=1 IndexM=0 IndexN=0 KC2=0 PropagationState=Undefined Attenuation=0 PolarizationState=TE AffectsRefinement} Mode{ModeNumber=2 IndexM=0 IndexN=0 KC2=0 PropagationState=Undefined Attenuation=0 PolarizationState=TM AffectsRefinement} Mode{ModeNumber=3 IndexM=-1 IndexN=0 KC2=385531421917553 PropagationState=Undefined Attenuation=1.7054704e+08 PolarizationState=TE AffectsRefinement} Mode{ModeNumber=4 IndexM=0 IndexN=-1 KC2=385531421917553 PropagationState=Undefined Attenuation=1.7054704e+08 PolarizationState=TE AffectsRefinement}}
setups:
  Setup1: HfssDriven Frequency=666.2THz MaxDeltaS=0.01 MaximumPasses=15 MinimumPasses=1 MinimumConvergedPasses=1 PercentRefinement=30 BasisOrder=1 PortAccuracy=2 DrivenSolverType="Direct Solver"
    sweep Varredura: 187.4THz to 666.2THz, 401 points; Type=Interpolating InterpTolerance=0.5 InterpMaxSolns=250 PassivityErrorTolerance=0.0001
source amplitudes:
  FloquetCima:1: 1W 0deg
  FloquetCima:2, FloquetCima:3, FloquetCima:4, FloquetBaixo:1..FloquetBaixo:4: 0W 0deg

design G1314_anelQ_quadrado (HFSS, HFSS Modal Network, model units um)
variables:
  theta_inc = 0deg
geometry:
  Au_anelq [Au_JC] = box(corner=(-0.12um, -0.12um, 0um), size=(0.24um, 0.24um, 0.03um))
  Au_anelq_furo = box(corner=(-0.088um, -0.088um, 0um), size=(0.176um, 0.176um, 0.03um))
  Au_anelq.subtract(Au_anelq_furo)
  Au_quadrado = box(corner=(-0.0225um, -0.0225um, 0um), size=(0.045um, 0.045um, 0.03um))
  Au_anelq.unite(Au_quadrado)
  Air_Domain [vacuum] = box(corner=(-0.16um, -0.16um, -1um), size=(0.32um, 0.32um, 2.03um))
  Au_anelq_1 = Au_anelq.copy()
  Air_Domain.subtract(Au_anelq_1)
boundaries and excitations:
  LatticePair_MVPBHG: Lattice Pair Faces=Air_Domain.face(-x, +x) CoordSysVector{(-0.16, -0.16, -1) -> (-0.16, -0.16, 1.03)} PhaseDelay=UseScanAngle Phi=0deg Theta=theta_inc
  LatticePair_UBJINU: Lattice Pair Faces=Air_Domain.face(-y, +y) CoordSysVector{(0.16, -0.16, -1) -> (0.16, -0.16, 1.03)} PhaseDelay=UseScanAngle Phi=0deg Theta=theta_inc
  FloquetCima: Floquet Port Faces=Air_Domain.face(+z) NumModes=4 Modes{Mode1{CharImp=Zpi} Mode2{CharImp=Zpi} Mode3{CharImp=Zpi} Mode4{CharImp=Zpi}} PhaseDelay=UseScanAngle Phi=0deg Theta=theta_inc LatticeAVector{(-0.16, -0.16, 1.03) -> (0.16, -0.16, 1.03)} LatticeBVector{(-0.16, -0.16, 1.03) -> (-0.16, 0.16, 1.03)} ModesCalculator{Frequency=1GHz PhiStart=0deg PhiStop=0deg PhiStep=0deg ThetaStart=0deg ThetaStop=0deg ThetaStep=0deg} ModesList{Mode{ModeNumber=1 IndexM=0 IndexN=0 KC2=0 PropagationState=Undefined Attenuation=0 PolarizationState=TE AffectsRefinement} Mode{ModeNumber=2 IndexM=0 IndexN=0 KC2=0 PropagationState=Undefined Attenuation=0 PolarizationState=TM AffectsRefinement} Mode{ModeNumber=3 IndexM=-1 IndexN=0 KC2=385531421917553 PropagationState=Undefined Attenuation=1.7054704e+08 PolarizationState=TE AffectsRefinement} Mode{ModeNumber=4 IndexM=0 IndexN=-1 KC2=385531421917553 PropagationState=Undefined Attenuation=1.7054704e+08 PolarizationState=TE AffectsRefinement}}
  FloquetBaixo: Floquet Port Faces=Air_Domain.face(-z) NumModes=4 Modes{Mode1{CharImp=Zpi} Mode2{CharImp=Zpi} Mode3{CharImp=Zpi} Mode4{CharImp=Zpi}} PhaseDelay=UseScanAngle Phi=0deg Theta=theta_inc LatticeAVector{(-0.16, -0.16, -1) -> (0.16, -0.16, -1)} LatticeBVector{(-0.16, -0.16, -1) -> (-0.16, 0.16, -1)} ModesCalculator{Frequency=1GHz PhiStart=0deg PhiStop=0deg PhiStep=0deg ThetaStart=0deg ThetaStop=0deg ThetaStep=0deg} ModesList{Mode{ModeNumber=1 IndexM=0 IndexN=0 KC2=0 PropagationState=Undefined Attenuation=0 PolarizationState=TE AffectsRefinement} Mode{ModeNumber=2 IndexM=0 IndexN=0 KC2=0 PropagationState=Undefined Attenuation=0 PolarizationState=TM AffectsRefinement} Mode{ModeNumber=3 IndexM=-1 IndexN=0 KC2=385531421917553 PropagationState=Undefined Attenuation=1.7054704e+08 PolarizationState=TE AffectsRefinement} Mode{ModeNumber=4 IndexM=0 IndexN=-1 KC2=385531421917553 PropagationState=Undefined Attenuation=1.7054704e+08 PolarizationState=TE AffectsRefinement}}
setups:
  Setup1: HfssDriven Frequency=666.2THz MaxDeltaS=0.01 MaximumPasses=15 MinimumPasses=1 MinimumConvergedPasses=1 PercentRefinement=30 BasisOrder=1 PortAccuracy=2 DrivenSolverType="Direct Solver"
    sweep Varredura: 187.4THz to 666.2THz, 401 points; Type=Interpolating InterpTolerance=0.5 InterpMaxSolns=250 PassivityErrorTolerance=0.0001
source amplitudes:
  FloquetCima:1: 1W 0deg
  FloquetCima:2, FloquetCima:3, FloquetCima:4, FloquetBaixo:1..FloquetBaixo:4: 0W 0deg

design G1206_anelQ_quadrado (HFSS, HFSS Modal Network, model units um)
variables:
  theta_inc = 0deg
geometry:
  Au_anelq [Au_JC] = box(corner=(-0.108um, -0.108um, 0um), size=(0.216um, 0.216um, 0.03um))
  Au_anelq_furo = box(corner=(-0.071um, -0.071um, 0um), size=(0.142um, 0.142um, 0.03um))
  Au_anelq.subtract(Au_anelq_furo)
  Au_quadrado = box(corner=(-0.0275um, -0.0275um, 0um), size=(0.055um, 0.055um, 0.03um))
  Au_anelq.unite(Au_quadrado)
  Air_Domain [vacuum] = box(corner=(-0.16um, -0.16um, -1um), size=(0.32um, 0.32um, 2.03um))
  Au_anelq_1 = Au_anelq.copy()
  Air_Domain.subtract(Au_anelq_1)
boundaries and excitations:
  LatticePair_I1V4B7: Lattice Pair Faces=Air_Domain.face(-x, +x) CoordSysVector{(-0.16, -0.16, -1) -> (-0.16, -0.16, 1.03)} PhaseDelay=UseScanAngle Phi=0deg Theta=theta_inc
  LatticePair_324GTG: Lattice Pair Faces=Air_Domain.face(-y, +y) CoordSysVector{(0.16, -0.16, -1) -> (0.16, -0.16, 1.03)} PhaseDelay=UseScanAngle Phi=0deg Theta=theta_inc
  FloquetCima: Floquet Port Faces=Air_Domain.face(+z) NumModes=4 Modes{Mode1{CharImp=Zpi} Mode2{CharImp=Zpi} Mode3{CharImp=Zpi} Mode4{CharImp=Zpi}} PhaseDelay=UseScanAngle Phi=0deg Theta=theta_inc LatticeAVector{(-0.16, -0.16, 1.03) -> (0.16, -0.16, 1.03)} LatticeBVector{(-0.16, -0.16, 1.03) -> (-0.16, 0.16, 1.03)} ModesCalculator{Frequency=1GHz PhiStart=0deg PhiStop=0deg PhiStep=0deg ThetaStart=0deg ThetaStop=0deg ThetaStep=0deg} ModesList{Mode{ModeNumber=1 IndexM=0 IndexN=0 KC2=0 PropagationState=Undefined Attenuation=0 PolarizationState=TE AffectsRefinement} Mode{ModeNumber=2 IndexM=0 IndexN=0 KC2=0 PropagationState=Undefined Attenuation=0 PolarizationState=TM AffectsRefinement} Mode{ModeNumber=3 IndexM=-1 IndexN=0 KC2=385531421917553 PropagationState=Undefined Attenuation=1.7054704e+08 PolarizationState=TE AffectsRefinement} Mode{ModeNumber=4 IndexM=0 IndexN=-1 KC2=385531421917553 PropagationState=Undefined Attenuation=1.7054704e+08 PolarizationState=TE AffectsRefinement}}
  FloquetBaixo: Floquet Port Faces=Air_Domain.face(-z) NumModes=4 Modes{Mode1{CharImp=Zpi} Mode2{CharImp=Zpi} Mode3{CharImp=Zpi} Mode4{CharImp=Zpi}} PhaseDelay=UseScanAngle Phi=0deg Theta=theta_inc LatticeAVector{(-0.16, -0.16, -1) -> (0.16, -0.16, -1)} LatticeBVector{(-0.16, -0.16, -1) -> (-0.16, 0.16, -1)} ModesCalculator{Frequency=1GHz PhiStart=0deg PhiStop=0deg PhiStep=0deg ThetaStart=0deg ThetaStop=0deg ThetaStep=0deg} ModesList{Mode{ModeNumber=1 IndexM=0 IndexN=0 KC2=0 PropagationState=Undefined Attenuation=0 PolarizationState=TE AffectsRefinement} Mode{ModeNumber=2 IndexM=0 IndexN=0 KC2=0 PropagationState=Undefined Attenuation=0 PolarizationState=TM AffectsRefinement} Mode{ModeNumber=3 IndexM=-1 IndexN=0 KC2=385531421917553 PropagationState=Undefined Attenuation=1.7054704e+08 PolarizationState=TE AffectsRefinement} Mode{ModeNumber=4 IndexM=0 IndexN=-1 KC2=385531421917553 PropagationState=Undefined Attenuation=1.7054704e+08 PolarizationState=TE AffectsRefinement}}
setups:
  Setup1: HfssDriven Frequency=666.2THz MaxDeltaS=0.01 MaximumPasses=15 MinimumPasses=1 MinimumConvergedPasses=1 PercentRefinement=30 BasisOrder=1 PortAccuracy=2 DrivenSolverType="Direct Solver"
    sweep Varredura: 187.4THz to 666.2THz, 401 points; Type=Interpolating InterpTolerance=0.5 InterpMaxSolns=250 PassivityErrorTolerance=0.0001
source amplitudes:
  FloquetCima:1: 1W 0deg
  FloquetCima:2, FloquetCima:3, FloquetCima:4, FloquetBaixo:1..FloquetBaixo:4: 0W 0deg

design G1316_anelQ_quadrado (HFSS, HFSS Modal Network, model units um)
variables:
  theta_inc = 0deg
geometry:
  Au_anelq [Au_JC] = box(corner=(-0.1035um, -0.1035um, 0um), size=(0.207um, 0.207um, 0.03um))
  Au_anelq_furo = box(corner=(-0.0775um, -0.0775um, 0um), size=(0.155um, 0.155um, 0.03um))
  Au_anelq.subtract(Au_anelq_furo)
  Au_quadrado = box(corner=(-0.028um, -0.028um, 0um), size=(0.056um, 0.056um, 0.03um))
  Au_anelq.unite(Au_quadrado)
  Air_Domain [vacuum] = box(corner=(-0.16um, -0.16um, -1um), size=(0.32um, 0.32um, 2.03um))
  Au_anelq_1 = Au_anelq.copy()
  Air_Domain.subtract(Au_anelq_1)
boundaries and excitations:
  LatticePair_NLREX7: Lattice Pair Faces=Air_Domain.face(-x, +x) CoordSysVector{(-0.16, -0.16, -1) -> (-0.16, -0.16, 1.03)} PhaseDelay=UseScanAngle Phi=0deg Theta=theta_inc
  LatticePair_5VMYLO: Lattice Pair Faces=Air_Domain.face(-y, +y) CoordSysVector{(0.16, -0.16, -1) -> (0.16, -0.16, 1.03)} PhaseDelay=UseScanAngle Phi=0deg Theta=theta_inc
  FloquetCima: Floquet Port Faces=Air_Domain.face(+z) NumModes=4 Modes{Mode1{CharImp=Zpi} Mode2{CharImp=Zpi} Mode3{CharImp=Zpi} Mode4{CharImp=Zpi}} PhaseDelay=UseScanAngle Phi=0deg Theta=theta_inc LatticeAVector{(-0.16, -0.16, 1.03) -> (0.16, -0.16, 1.03)} LatticeBVector{(-0.16, -0.16, 1.03) -> (-0.16, 0.16, 1.03)} ModesCalculator{Frequency=1GHz PhiStart=0deg PhiStop=0deg PhiStep=0deg ThetaStart=0deg ThetaStop=0deg ThetaStep=0deg} ModesList{Mode{ModeNumber=1 IndexM=0 IndexN=0 KC2=0 PropagationState=Undefined Attenuation=0 PolarizationState=TE AffectsRefinement} Mode{ModeNumber=2 IndexM=0 IndexN=0 KC2=0 PropagationState=Undefined Attenuation=0 PolarizationState=TM AffectsRefinement} Mode{ModeNumber=3 IndexM=-1 IndexN=0 KC2=385531421917553 PropagationState=Undefined Attenuation=1.7054704e+08 PolarizationState=TE AffectsRefinement} Mode{ModeNumber=4 IndexM=0 IndexN=-1 KC2=385531421917553 PropagationState=Undefined Attenuation=1.7054704e+08 PolarizationState=TE AffectsRefinement}}
  FloquetBaixo: Floquet Port Faces=Air_Domain.face(-z) NumModes=4 Modes{Mode1{CharImp=Zpi} Mode2{CharImp=Zpi} Mode3{CharImp=Zpi} Mode4{CharImp=Zpi}} PhaseDelay=UseScanAngle Phi=0deg Theta=theta_inc LatticeAVector{(-0.16, -0.16, -1) -> (0.16, -0.16, -1)} LatticeBVector{(-0.16, -0.16, -1) -> (-0.16, 0.16, -1)} ModesCalculator{Frequency=1GHz PhiStart=0deg PhiStop=0deg PhiStep=0deg ThetaStart=0deg ThetaStop=0deg ThetaStep=0deg} ModesList{Mode{ModeNumber=1 IndexM=0 IndexN=0 KC2=0 PropagationState=Undefined Attenuation=0 PolarizationState=TE AffectsRefinement} Mode{ModeNumber=2 IndexM=0 IndexN=0 KC2=0 PropagationState=Undefined Attenuation=0 PolarizationState=TM AffectsRefinement} Mode{ModeNumber=3 IndexM=-1 IndexN=0 KC2=385531421917553 PropagationState=Undefined Attenuation=1.7054704e+08 PolarizationState=TE AffectsRefinement} Mode{ModeNumber=4 IndexM=0 IndexN=-1 KC2=385531421917553 PropagationState=Undefined Attenuation=1.7054704e+08 PolarizationState=TE AffectsRefinement}}
setups:
  Setup1: HfssDriven Frequency=666.2THz MaxDeltaS=0.01 MaximumPasses=15 MinimumPasses=1 MinimumConvergedPasses=1 PercentRefinement=30 BasisOrder=1 PortAccuracy=2 DrivenSolverType="Direct Solver"
    sweep Varredura: 187.4THz to 666.2THz, 401 points; Type=Interpolating InterpTolerance=0.5 InterpMaxSolns=250 PassivityErrorTolerance=0.0001
source amplitudes:
  FloquetCima:1: 1W 0deg
  FloquetCima:2, FloquetCima:3, FloquetCima:4, FloquetBaixo:1..FloquetBaixo:4: 0W 0deg

design G1368_anelQ_quadrado (HFSS, HFSS Modal Network, model units um)
variables:
  theta_inc = 0deg
geometry:
  Au_anelq [Au_JC] = box(corner=(-0.0845um, -0.0845um, 0um), size=(0.169um, 0.169um, 0.03um))
  Au_anelq_furo = box(corner=(-0.0545um, -0.0545um, 0um), size=(0.109um, 0.109um, 0.03um))
  Au_anelq.subtract(Au_anelq_furo)
  Au_quadrado = box(corner=(-0.029um, -0.029um, 0um), size=(0.058um, 0.058um, 0.03um))
  Au_anelq.unite(Au_quadrado)
  Air_Domain [vacuum] = box(corner=(-0.16um, -0.16um, -1um), size=(0.32um, 0.32um, 2.03um))
  Au_anelq_1 = Au_anelq.copy()
  Air_Domain.subtract(Au_anelq_1)
boundaries and excitations:
  LatticePair_S050S0: Lattice Pair Faces=Air_Domain.face(-x, +x) CoordSysVector{(-0.16, -0.16, -1) -> (-0.16, -0.16, 1.03)} PhaseDelay=UseScanAngle Phi=0deg Theta=theta_inc
  LatticePair_J1O6TZ: Lattice Pair Faces=Air_Domain.face(-y, +y) CoordSysVector{(0.16, -0.16, -1) -> (0.16, -0.16, 1.03)} PhaseDelay=UseScanAngle Phi=0deg Theta=theta_inc
  FloquetCima: Floquet Port Faces=Air_Domain.face(+z) NumModes=4 Modes{Mode1{CharImp=Zpi} Mode2{CharImp=Zpi} Mode3{CharImp=Zpi} Mode4{CharImp=Zpi}} PhaseDelay=UseScanAngle Phi=0deg Theta=theta_inc LatticeAVector{(-0.16, -0.16, 1.03) -> (0.16, -0.16, 1.03)} LatticeBVector{(-0.16, -0.16, 1.03) -> (-0.16, 0.16, 1.03)} ModesCalculator{Frequency=1GHz PhiStart=0deg PhiStop=0deg PhiStep=0deg ThetaStart=0deg ThetaStop=0deg ThetaStep=0deg} ModesList{Mode{ModeNumber=1 IndexM=0 IndexN=0 KC2=0 PropagationState=Undefined Attenuation=0 PolarizationState=TE AffectsRefinement} Mode{ModeNumber=2 IndexM=0 IndexN=0 KC2=0 PropagationState=Undefined Attenuation=0 PolarizationState=TM AffectsRefinement} Mode{ModeNumber=3 IndexM=-1 IndexN=0 KC2=385531421917553 PropagationState=Undefined Attenuation=1.7054704e+08 PolarizationState=TE AffectsRefinement} Mode{ModeNumber=4 IndexM=0 IndexN=-1 KC2=385531421917553 PropagationState=Undefined Attenuation=1.7054704e+08 PolarizationState=TE AffectsRefinement}}
  FloquetBaixo: Floquet Port Faces=Air_Domain.face(-z) NumModes=4 Modes{Mode1{CharImp=Zpi} Mode2{CharImp=Zpi} Mode3{CharImp=Zpi} Mode4{CharImp=Zpi}} PhaseDelay=UseScanAngle Phi=0deg Theta=theta_inc LatticeAVector{(-0.16, -0.16, -1) -> (0.16, -0.16, -1)} LatticeBVector{(-0.16, -0.16, -1) -> (-0.16, 0.16, -1)} ModesCalculator{Frequency=1GHz PhiStart=0deg PhiStop=0deg PhiStep=0deg ThetaStart=0deg ThetaStop=0deg ThetaStep=0deg} ModesList{Mode{ModeNumber=1 IndexM=0 IndexN=0 KC2=0 PropagationState=Undefined Attenuation=0 PolarizationState=TE AffectsRefinement} Mode{ModeNumber=2 IndexM=0 IndexN=0 KC2=0 PropagationState=Undefined Attenuation=0 PolarizationState=TM AffectsRefinement} Mode{ModeNumber=3 IndexM=-1 IndexN=0 KC2=385531421917553 PropagationState=Undefined Attenuation=1.7054704e+08 PolarizationState=TE AffectsRefinement} Mode{ModeNumber=4 IndexM=0 IndexN=-1 KC2=385531421917553 PropagationState=Undefined Attenuation=1.7054704e+08 PolarizationState=TE AffectsRefinement}}
setups:
  Setup1: HfssDriven Frequency=666.2THz MaxDeltaS=0.01 MaximumPasses=15 MinimumPasses=1 MinimumConvergedPasses=1 PercentRefinement=30 BasisOrder=1 PortAccuracy=2 DrivenSolverType="Direct Solver"
    sweep Varredura: 187.4THz to 666.2THz, 401 points; Type=Interpolating InterpTolerance=0.5 InterpMaxSolns=250 PassivityErrorTolerance=0.0001
source amplitudes:
  FloquetCima:1: 1W 0deg
  FloquetCima:2, FloquetCima:3, FloquetCima:4, FloquetBaixo:1..FloquetBaixo:4: 0W 0deg

design G1377_anelQ_quadrado (HFSS, HFSS Modal Network, model units um)
variables:
  theta_inc = 0deg
geometry:
  Au_anelq [Au_JC] = box(corner=(-0.091um, -0.091um, 0um), size=(0.182um, 0.182um, 0.03um))
  Au_anelq_furo = box(corner=(-0.054um, -0.054um, 0um), size=(0.108um, 0.108um, 0.03um))
  Au_anelq.subtract(Au_anelq_furo)
  Au_quadrado = box(corner=(-0.032um, -0.032um, 0um), size=(0.064um, 0.064um, 0.03um))
  Au_anelq.unite(Au_quadrado)
  Air_Domain [vacuum] = box(corner=(-0.16um, -0.16um, -1um), size=(0.32um, 0.32um, 2.03um))
  Au_anelq_1 = Au_anelq.copy()
  Air_Domain.subtract(Au_anelq_1)
boundaries and excitations:
  LatticePair_S45V2L: Lattice Pair Faces=Air_Domain.face(-x, +x) CoordSysVector{(-0.16, -0.16, -1) -> (-0.16, -0.16, 1.03)} PhaseDelay=UseScanAngle Phi=0deg Theta=theta_inc
  LatticePair_DS57YH: Lattice Pair Faces=Air_Domain.face(-y, +y) CoordSysVector{(0.16, -0.16, -1) -> (0.16, -0.16, 1.03)} PhaseDelay=UseScanAngle Phi=0deg Theta=theta_inc
  FloquetCima: Floquet Port Faces=Air_Domain.face(+z) NumModes=4 Modes{Mode1{CharImp=Zpi} Mode2{CharImp=Zpi} Mode3{CharImp=Zpi} Mode4{CharImp=Zpi}} PhaseDelay=UseScanAngle Phi=0deg Theta=theta_inc LatticeAVector{(-0.16, -0.16, 1.03) -> (0.16, -0.16, 1.03)} LatticeBVector{(-0.16, -0.16, 1.03) -> (-0.16, 0.16, 1.03)} ModesCalculator{Frequency=1GHz PhiStart=0deg PhiStop=0deg PhiStep=0deg ThetaStart=0deg ThetaStop=0deg ThetaStep=0deg} ModesList{Mode{ModeNumber=1 IndexM=0 IndexN=0 KC2=0 PropagationState=Undefined Attenuation=0 PolarizationState=TE AffectsRefinement} Mode{ModeNumber=2 IndexM=0 IndexN=0 KC2=0 PropagationState=Undefined Attenuation=0 PolarizationState=TM AffectsRefinement} Mode{ModeNumber=3 IndexM=-1 IndexN=0 KC2=385531421917553 PropagationState=Undefined Attenuation=1.7054704e+08 PolarizationState=TE AffectsRefinement} Mode{ModeNumber=4 IndexM=0 IndexN=-1 KC2=385531421917553 PropagationState=Undefined Attenuation=1.7054704e+08 PolarizationState=TE AffectsRefinement}}
  FloquetBaixo: Floquet Port Faces=Air_Domain.face(-z) NumModes=4 Modes{Mode1{CharImp=Zpi} Mode2{CharImp=Zpi} Mode3{CharImp=Zpi} Mode4{CharImp=Zpi}} PhaseDelay=UseScanAngle Phi=0deg Theta=theta_inc LatticeAVector{(-0.16, -0.16, -1) -> (0.16, -0.16, -1)} LatticeBVector{(-0.16, -0.16, -1) -> (-0.16, 0.16, -1)} ModesCalculator{Frequency=1GHz PhiStart=0deg PhiStop=0deg PhiStep=0deg ThetaStart=0deg ThetaStop=0deg ThetaStep=0deg} ModesList{Mode{ModeNumber=1 IndexM=0 IndexN=0 KC2=0 PropagationState=Undefined Attenuation=0 PolarizationState=TE AffectsRefinement} Mode{ModeNumber=2 IndexM=0 IndexN=0 KC2=0 PropagationState=Undefined Attenuation=0 PolarizationState=TM AffectsRefinement} Mode{ModeNumber=3 IndexM=-1 IndexN=0 KC2=385531421917553 PropagationState=Undefined Attenuation=1.7054704e+08 PolarizationState=TE AffectsRefinement} Mode{ModeNumber=4 IndexM=0 IndexN=-1 KC2=385531421917553 PropagationState=Undefined Attenuation=1.7054704e+08 PolarizationState=TE AffectsRefinement}}
setups:
  Setup1: HfssDriven Frequency=666.2THz MaxDeltaS=0.01 MaximumPasses=15 MinimumPasses=1 MinimumConvergedPasses=1 PercentRefinement=30 BasisOrder=1 PortAccuracy=2 DrivenSolverType="Direct Solver"
    sweep Varredura: 187.4THz to 666.2THz, 401 points; Type=Interpolating InterpTolerance=0.5 InterpMaxSolns=250 PassivityErrorTolerance=0.0001
source amplitudes:
  FloquetCima:1: 1W 0deg
  FloquetCima:2, FloquetCima:3, FloquetCima:4, FloquetBaixo:1..FloquetBaixo:4: 0W 0deg

design G1341_anelQ_quadrado (HFSS, HFSS Modal Network, model units um)
variables:
  theta_inc = 0deg
geometry:
  Au_anelq [Au_JC] = box(corner=(-0.1095um, -0.1095um, 0um), size=(0.219um, 0.219um, 0.03um))
  Au_anelq_furo = box(corner=(-0.0715um, -0.0715um, 0um), size=(0.143um, 0.143um, 0.03um))
  Au_anelq.subtract(Au_anelq_furo)
  Au_quadrado = box(corner=(-0.0405um, -0.0405um, 0um), size=(0.081um, 0.081um, 0.03um))
  Au_anelq.unite(Au_quadrado)
  Air_Domain [vacuum] = box(corner=(-0.16um, -0.16um, -1um), size=(0.32um, 0.32um, 2.03um))
  Au_anelq_1 = Au_anelq.copy()
  Air_Domain.subtract(Au_anelq_1)
boundaries and excitations:
  LatticePair_CL22VD: Lattice Pair Faces=Air_Domain.face(-x, +x) CoordSysVector{(-0.16, -0.16, -1) -> (-0.16, -0.16, 1.03)} PhaseDelay=UseScanAngle Phi=0deg Theta=theta_inc
  LatticePair_ZGENPA: Lattice Pair Faces=Air_Domain.face(-y, +y) CoordSysVector{(0.16, -0.16, -1) -> (0.16, -0.16, 1.03)} PhaseDelay=UseScanAngle Phi=0deg Theta=theta_inc
  FloquetCima: Floquet Port Faces=Air_Domain.face(+z) NumModes=4 Modes{Mode1{CharImp=Zpi} Mode2{CharImp=Zpi} Mode3{CharImp=Zpi} Mode4{CharImp=Zpi}} PhaseDelay=UseScanAngle Phi=0deg Theta=theta_inc LatticeAVector{(-0.16, -0.16, 1.03) -> (0.16, -0.16, 1.03)} LatticeBVector{(-0.16, -0.16, 1.03) -> (-0.16, 0.16, 1.03)} ModesCalculator{Frequency=1GHz PhiStart=0deg PhiStop=0deg PhiStep=0deg ThetaStart=0deg ThetaStop=0deg ThetaStep=0deg} ModesList{Mode{ModeNumber=1 IndexM=0 IndexN=0 KC2=0 PropagationState=Undefined Attenuation=0 PolarizationState=TE AffectsRefinement} Mode{ModeNumber=2 IndexM=0 IndexN=0 KC2=0 PropagationState=Undefined Attenuation=0 PolarizationState=TM AffectsRefinement} Mode{ModeNumber=3 IndexM=-1 IndexN=0 KC2=385531421917553 PropagationState=Undefined Attenuation=1.7054704e+08 PolarizationState=TE AffectsRefinement} Mode{ModeNumber=4 IndexM=0 IndexN=-1 KC2=385531421917553 PropagationState=Undefined Attenuation=1.7054704e+08 PolarizationState=TE AffectsRefinement}}
  FloquetBaixo: Floquet Port Faces=Air_Domain.face(-z) NumModes=4 Modes{Mode1{CharImp=Zpi} Mode2{CharImp=Zpi} Mode3{CharImp=Zpi} Mode4{CharImp=Zpi}} PhaseDelay=UseScanAngle Phi=0deg Theta=theta_inc LatticeAVector{(-0.16, -0.16, -1) -> (0.16, -0.16, -1)} LatticeBVector{(-0.16, -0.16, -1) -> (-0.16, 0.16, -1)} ModesCalculator{Frequency=1GHz PhiStart=0deg PhiStop=0deg PhiStep=0deg ThetaStart=0deg ThetaStop=0deg ThetaStep=0deg} ModesList{Mode{ModeNumber=1 IndexM=0 IndexN=0 KC2=0 PropagationState=Undefined Attenuation=0 PolarizationState=TE AffectsRefinement} Mode{ModeNumber=2 IndexM=0 IndexN=0 KC2=0 PropagationState=Undefined Attenuation=0 PolarizationState=TM AffectsRefinement} Mode{ModeNumber=3 IndexM=-1 IndexN=0 KC2=385531421917553 PropagationState=Undefined Attenuation=1.7054704e+08 PolarizationState=TE AffectsRefinement} Mode{ModeNumber=4 IndexM=0 IndexN=-1 KC2=385531421917553 PropagationState=Undefined Attenuation=1.7054704e+08 PolarizationState=TE AffectsRefinement}}
setups:
  Setup1: HfssDriven Frequency=666.2THz MaxDeltaS=0.01 MaximumPasses=15 MinimumPasses=1 MinimumConvergedPasses=1 PercentRefinement=30 BasisOrder=1 PortAccuracy=2 DrivenSolverType="Direct Solver"
    sweep Varredura: 187.4THz to 666.2THz, 401 points; Type=Interpolating InterpTolerance=0.5 InterpMaxSolns=250 PassivityErrorTolerance=0.0001
source amplitudes:
  FloquetCima:1: 1W 0deg
  FloquetCima:2, FloquetCima:3, FloquetCima:4, FloquetBaixo:1..FloquetBaixo:4: 0W 0deg

design G1328_anelQ_quadrado (HFSS, HFSS Modal Network, model units um)
variables:
  theta_inc = 0deg
geometry:
  Au_anelq [Au_JC] = box(corner=(-0.086um, -0.086um, 0um), size=(0.172um, 0.172um, 0.03um))
  Au_anelq_furo = box(corner=(-0.053um, -0.053um, 0um), size=(0.106um, 0.106um, 0.03um))
  Au_anelq.subtract(Au_anelq_furo)
  Au_quadrado = box(corner=(-0.037um, -0.037um, 0um), size=(0.074um, 0.074um, 0.03um))
  Au_anelq.unite(Au_quadrado)
  Air_Domain [vacuum] = box(corner=(-0.16um, -0.16um, -1um), size=(0.32um, 0.32um, 2.03um))
  Au_anelq_1 = Au_anelq.copy()
  Air_Domain.subtract(Au_anelq_1)
boundaries and excitations:
  LatticePair_8NVEGN: Lattice Pair Faces=Air_Domain.face(-x, +x) CoordSysVector{(-0.16, -0.16, -1) -> (-0.16, -0.16, 1.03)} PhaseDelay=UseScanAngle Phi=0deg Theta=theta_inc
  LatticePair_R0PV13: Lattice Pair Faces=Air_Domain.face(-y, +y) CoordSysVector{(0.16, -0.16, -1) -> (0.16, -0.16, 1.03)} PhaseDelay=UseScanAngle Phi=0deg Theta=theta_inc
  FloquetCima: Floquet Port Faces=Air_Domain.face(+z) NumModes=4 Modes{Mode1{CharImp=Zpi} Mode2{CharImp=Zpi} Mode3{CharImp=Zpi} Mode4{CharImp=Zpi}} PhaseDelay=UseScanAngle Phi=0deg Theta=theta_inc LatticeAVector{(-0.16, -0.16, 1.03) -> (0.16, -0.16, 1.03)} LatticeBVector{(-0.16, -0.16, 1.03) -> (-0.16, 0.16, 1.03)} ModesCalculator{Frequency=1GHz PhiStart=0deg PhiStop=0deg PhiStep=0deg ThetaStart=0deg ThetaStop=0deg ThetaStep=0deg} ModesList{Mode{ModeNumber=1 IndexM=0 IndexN=0 KC2=0 PropagationState=Undefined Attenuation=0 PolarizationState=TE AffectsRefinement} Mode{ModeNumber=2 IndexM=0 IndexN=0 KC2=0 PropagationState=Undefined Attenuation=0 PolarizationState=TM AffectsRefinement} Mode{ModeNumber=3 IndexM=-1 IndexN=0 KC2=385531421917553 PropagationState=Undefined Attenuation=1.7054704e+08 PolarizationState=TE AffectsRefinement} Mode{ModeNumber=4 IndexM=0 IndexN=-1 KC2=385531421917553 PropagationState=Undefined Attenuation=1.7054704e+08 PolarizationState=TE AffectsRefinement}}
  FloquetBaixo: Floquet Port Faces=Air_Domain.face(-z) NumModes=4 Modes{Mode1{CharImp=Zpi} Mode2{CharImp=Zpi} Mode3{CharImp=Zpi} Mode4{CharImp=Zpi}} PhaseDelay=UseScanAngle Phi=0deg Theta=theta_inc LatticeAVector{(-0.16, -0.16, -1) -> (0.16, -0.16, -1)} LatticeBVector{(-0.16, -0.16, -1) -> (-0.16, 0.16, -1)} ModesCalculator{Frequency=1GHz PhiStart=0deg PhiStop=0deg PhiStep=0deg ThetaStart=0deg ThetaStop=0deg ThetaStep=0deg} ModesList{Mode{ModeNumber=1 IndexM=0 IndexN=0 KC2=0 PropagationState=Undefined Attenuation=0 PolarizationState=TE AffectsRefinement} Mode{ModeNumber=2 IndexM=0 IndexN=0 KC2=0 PropagationState=Undefined Attenuation=0 PolarizationState=TM AffectsRefinement} Mode{ModeNumber=3 IndexM=-1 IndexN=0 KC2=385531421917553 PropagationState=Undefined Attenuation=1.7054704e+08 PolarizationState=TE AffectsRefinement} Mode{ModeNumber=4 IndexM=0 IndexN=-1 KC2=385531421917553 PropagationState=Undefined Attenuation=1.7054704e+08 PolarizationState=TE AffectsRefinement}}
setups:
  Setup1: HfssDriven Frequency=666.2THz MaxDeltaS=0.01 MaximumPasses=15 MinimumPasses=1 MinimumConvergedPasses=1 PercentRefinement=30 BasisOrder=1 PortAccuracy=2 DrivenSolverType="Direct Solver"
    sweep Varredura: 187.4THz to 666.2THz, 401 points; Type=Interpolating InterpTolerance=0.5 InterpMaxSolns=250 PassivityErrorTolerance=0.0001
source amplitudes:
  FloquetCima:1: 1W 0deg
  FloquetCima:2, FloquetCima:3, FloquetCima:4, FloquetBaixo:1..FloquetBaixo:4: 0W 0deg

design G1560_anelQ_quadrado_trilhas (HFSS, HFSS Modal Network, model units um)
variables:
  theta_inc = 0deg
geometry:
  Au_anelq [Au_JC] = box(corner=(-0.1125um, -0.1125um, 0um), size=(0.225um, 0.225um, 0.03um))
  Au_anelq_furo = box(corner=(-0.0715um, -0.0715um, 0um), size=(0.143um, 0.143um, 0.03um))
  Au_anelq.subtract(Au_anelq_furo)
  Au_quadrado = box(corner=(-0.027um, -0.027um, 0um), size=(0.054um, 0.054um, 0.03um))
  Au_trilha0 = box(corner=(0.017um, -0.01um, 0um), size=(0.075um, 0.02um, 0.03um))
  Au_trilha1 = box(corner=(-0.092um, -0.01um, 0um), size=(0.075um, 0.02um, 0.03um))
  Au_trilha2 = box(corner=(-0.01um, 0.017um, 0um), size=(0.02um, 0.075um, 0.03um))
  Au_trilha3 = box(corner=(-0.01um, -0.092um, 0um), size=(0.02um, 0.075um, 0.03um))
  Au_anelq.unite(Au_quadrado, Au_trilha0..Au_trilha3)
  Air_Domain [vacuum] = box(corner=(-0.16um, -0.16um, -1um), size=(0.32um, 0.32um, 2.03um))
  Au_anelq_1 = Au_anelq.copy()
  Air_Domain.subtract(Au_anelq_1)
boundaries and excitations:
  LatticePair_G4XRZ7: Lattice Pair Faces=Air_Domain.face(-x, +x) CoordSysVector{(-0.16, -0.16, -1) -> (-0.16, -0.16, 1.03)} PhaseDelay=UseScanAngle Phi=0deg Theta=theta_inc
  LatticePair_IUZ3EP: Lattice Pair Faces=Air_Domain.face(-y, +y) CoordSysVector{(0.16, -0.16, -1) -> (0.16, -0.16, 1.03)} PhaseDelay=UseScanAngle Phi=0deg Theta=theta_inc
  FloquetCima: Floquet Port Faces=Air_Domain.face(+z) NumModes=4 Modes{Mode1{CharImp=Zpi} Mode2{CharImp=Zpi} Mode3{CharImp=Zpi} Mode4{CharImp=Zpi}} PhaseDelay=UseScanAngle Phi=0deg Theta=theta_inc LatticeAVector{(-0.16, -0.16, 1.03) -> (0.16, -0.16, 1.03)} LatticeBVector{(-0.16, -0.16, 1.03) -> (-0.16, 0.16, 1.03)} ModesCalculator{Frequency=1GHz PhiStart=0deg PhiStop=0deg PhiStep=0deg ThetaStart=0deg ThetaStop=0deg ThetaStep=0deg} ModesList{Mode{ModeNumber=1 IndexM=0 IndexN=0 KC2=0 PropagationState=Undefined Attenuation=0 PolarizationState=TE AffectsRefinement} Mode{ModeNumber=2 IndexM=0 IndexN=0 KC2=0 PropagationState=Undefined Attenuation=0 PolarizationState=TM AffectsRefinement} Mode{ModeNumber=3 IndexM=-1 IndexN=0 KC2=385531421917553 PropagationState=Undefined Attenuation=1.7054704e+08 PolarizationState=TE AffectsRefinement} Mode{ModeNumber=4 IndexM=0 IndexN=-1 KC2=385531421917553 PropagationState=Undefined Attenuation=1.7054704e+08 PolarizationState=TE AffectsRefinement}}
  FloquetBaixo: Floquet Port Faces=Air_Domain.face(-z) NumModes=4 Modes{Mode1{CharImp=Zpi} Mode2{CharImp=Zpi} Mode3{CharImp=Zpi} Mode4{CharImp=Zpi}} PhaseDelay=UseScanAngle Phi=0deg Theta=theta_inc LatticeAVector{(-0.16, -0.16, -1) -> (0.16, -0.16, -1)} LatticeBVector{(-0.16, -0.16, -1) -> (-0.16, 0.16, -1)} ModesCalculator{Frequency=1GHz PhiStart=0deg PhiStop=0deg PhiStep=0deg ThetaStart=0deg ThetaStop=0deg ThetaStep=0deg} ModesList{Mode{ModeNumber=1 IndexM=0 IndexN=0 KC2=0 PropagationState=Undefined Attenuation=0 PolarizationState=TE AffectsRefinement} Mode{ModeNumber=2 IndexM=0 IndexN=0 KC2=0 PropagationState=Undefined Attenuation=0 PolarizationState=TM AffectsRefinement} Mode{ModeNumber=3 IndexM=-1 IndexN=0 KC2=385531421917553 PropagationState=Undefined Attenuation=1.7054704e+08 PolarizationState=TE AffectsRefinement} Mode{ModeNumber=4 IndexM=0 IndexN=-1 KC2=385531421917553 PropagationState=Undefined Attenuation=1.7054704e+08 PolarizationState=TE AffectsRefinement}}
setups:
  Setup1: HfssDriven Frequency=666.2THz MaxDeltaS=0.01 MaximumPasses=15 MinimumPasses=1 MinimumConvergedPasses=1 PercentRefinement=30 BasisOrder=1 PortAccuracy=2 DrivenSolverType="Direct Solver"
    sweep Varredura: 187.4THz to 666.2THz, 401 points; Type=Interpolating InterpTolerance=0.5 InterpMaxSolns=250 PassivityErrorTolerance=0.0001
source amplitudes:
  FloquetCima:1: 1W 0deg
  FloquetCima:2, FloquetCima:3, FloquetCima:4, FloquetBaixo:1..FloquetBaixo:4: 0W 0deg

design G1442_anelQ_quadrado_trilhas (HFSS, HFSS Modal Network, model units um)
variables:
  theta_inc = 0deg
geometry:
  Au_anelq [Au_JC] = box(corner=(-0.118um, -0.118um, 0um), size=(0.236um, 0.236um, 0.03um))
  Au_anelq_furo = box(corner=(-0.089um, -0.089um, 0um), size=(0.178um, 0.178um, 0.03um))
  Au_anelq.subtract(Au_anelq_furo)
  Au_quadrado = box(corner=(-0.0765um, -0.0765um, 0um), size=(0.153um, 0.153um, 0.03um))
  Au_trilha0 = box(corner=(0.0665um, -0.012um, 0um), size=(0.037um, 0.024um, 0.03um))
  Au_trilha1 = box(corner=(-0.1035um, -0.012um, 0um), size=(0.037um, 0.024um, 0.03um))
  Au_trilha2 = box(corner=(-0.012um, 0.0665um, 0um), size=(0.024um, 0.037um, 0.03um))
  Au_trilha3 = box(corner=(-0.012um, -0.1035um, 0um), size=(0.024um, 0.037um, 0.03um))
  Au_anelq.unite(Au_quadrado, Au_trilha0..Au_trilha3)
  Air_Domain [vacuum] = box(corner=(-0.16um, -0.16um, -1um), size=(0.32um, 0.32um, 2.03um))
  Au_anelq_1 = Au_anelq.copy()
  Air_Domain.subtract(Au_anelq_1)
boundaries and excitations:
  LatticePair_Z8TR38: Lattice Pair Faces=Air_Domain.face(-x, +x) CoordSysVector{(-0.16, -0.16, -1) -> (-0.16, -0.16, 1.03)} PhaseDelay=UseScanAngle Phi=0deg Theta=theta_inc
  LatticePair_AMUSUF: Lattice Pair Faces=Air_Domain.face(-y, +y) CoordSysVector{(0.16, -0.16, -1) -> (0.16, -0.16, 1.03)} PhaseDelay=UseScanAngle Phi=0deg Theta=theta_inc
  FloquetCima: Floquet Port Faces=Air_Domain.face(+z) NumModes=4 Modes{Mode1{CharImp=Zpi} Mode2{CharImp=Zpi} Mode3{CharImp=Zpi} Mode4{CharImp=Zpi}} PhaseDelay=UseScanAngle Phi=0deg Theta=theta_inc LatticeAVector{(-0.16, -0.16, 1.03) -> (0.16, -0.16, 1.03)} LatticeBVector{(-0.16, -0.16, 1.03) -> (-0.16, 0.16, 1.03)} ModesCalculator{Frequency=1GHz PhiStart=0deg PhiStop=0deg PhiStep=0deg ThetaStart=0deg ThetaStop=0deg ThetaStep=0deg} ModesList{Mode{ModeNumber=1 IndexM=0 IndexN=0 KC2=0 PropagationState=Undefined Attenuation=0 PolarizationState=TE AffectsRefinement} Mode{ModeNumber=2 IndexM=0 IndexN=0 KC2=0 PropagationState=Undefined Attenuation=0 PolarizationState=TM AffectsRefinement} Mode{ModeNumber=3 IndexM=-1 IndexN=0 KC2=385531421917553 PropagationState=Undefined Attenuation=1.7054704e+08 PolarizationState=TE AffectsRefinement} Mode{ModeNumber=4 IndexM=0 IndexN=-1 KC2=385531421917553 PropagationState=Undefined Attenuation=1.7054704e+08 PolarizationState=TE AffectsRefinement}}
  FloquetBaixo: Floquet Port Faces=Air_Domain.face(-z) NumModes=4 Modes{Mode1{CharImp=Zpi} Mode2{CharImp=Zpi} Mode3{CharImp=Zpi} Mode4{CharImp=Zpi}} PhaseDelay=UseScanAngle Phi=0deg Theta=theta_inc LatticeAVector{(-0.16, -0.16, -1) -> (0.16, -0.16, -1)} LatticeBVector{(-0.16, -0.16, -1) -> (-0.16, 0.16, -1)} ModesCalculator{Frequency=1GHz PhiStart=0deg PhiStop=0deg PhiStep=0deg ThetaStart=0deg ThetaStop=0deg ThetaStep=0deg} ModesList{Mode{ModeNumber=1 IndexM=0 IndexN=0 KC2=0 PropagationState=Undefined Attenuation=0 PolarizationState=TE AffectsRefinement} Mode{ModeNumber=2 IndexM=0 IndexN=0 KC2=0 PropagationState=Undefined Attenuation=0 PolarizationState=TM AffectsRefinement} Mode{ModeNumber=3 IndexM=-1 IndexN=0 KC2=385531421917553 PropagationState=Undefined Attenuation=1.7054704e+08 PolarizationState=TE AffectsRefinement} Mode{ModeNumber=4 IndexM=0 IndexN=-1 KC2=385531421917553 PropagationState=Undefined Attenuation=1.7054704e+08 PolarizationState=TE AffectsRefinement}}
setups:
  Setup1: HfssDriven Frequency=666.2THz MaxDeltaS=0.01 MaximumPasses=15 MinimumPasses=1 MinimumConvergedPasses=1 PercentRefinement=30 BasisOrder=1 PortAccuracy=2 DrivenSolverType="Direct Solver"
    sweep Varredura: 187.4THz to 666.2THz, 401 points; Type=Interpolating InterpTolerance=0.5 InterpMaxSolns=250 PassivityErrorTolerance=0.0001
source amplitudes:
  FloquetCima:1: 1W 0deg
  FloquetCima:2, FloquetCima:3, FloquetCima:4, FloquetBaixo:1..FloquetBaixo:4: 0W 0deg

design G1583_anelQ_quadrado_trilhas (HFSS, HFSS Modal Network, model units um)
variables:
  theta_inc = 0deg
geometry:
  Au_anelq [Au_JC] = box(corner=(-0.1055um, -0.1055um, 0um), size=(0.211um, 0.211um, 0.03um))
  Au_anelq_furo = box(corner=(-0.0715um, -0.0715um, 0um), size=(0.143um, 0.143um, 0.03um))
  Au_anelq.subtract(Au_anelq_furo)
  Au_quadrado = box(corner=(-0.0555um, -0.0555um, 0um), size=(0.111um, 0.111um, 0.03um))
  Au_trilha0 = box(corner=(0.0455um, -0.008um, 0um), size=(0.043um, 0.016um, 0.03um))
  Au_trilha1 = box(corner=(-0.0885um, -0.008um, 0um), size=(0.043um, 0.016um, 0.03um))
  Au_trilha2 = box(corner=(-0.008um, 0.0455um, 0um), size=(0.016um, 0.043um, 0.03um))
  Au_trilha3 = box(corner=(-0.008um, -0.0885um, 0um), size=(0.016um, 0.043um, 0.03um))
  Au_anelq.unite(Au_quadrado, Au_trilha0..Au_trilha3)
  Air_Domain [vacuum] = box(corner=(-0.16um, -0.16um, -1um), size=(0.32um, 0.32um, 2.03um))
  Au_anelq_1 = Au_anelq.copy()
  Air_Domain.subtract(Au_anelq_1)
boundaries and excitations:
  LatticePair_GAG8D1: Lattice Pair Faces=Air_Domain.face(-x, +x) CoordSysVector{(-0.16, -0.16, -1) -> (-0.16, -0.16, 1.03)} PhaseDelay=UseScanAngle Phi=0deg Theta=theta_inc
  LatticePair_F9O10K: Lattice Pair Faces=Air_Domain.face(-y, +y) CoordSysVector{(0.16, -0.16, -1) -> (0.16, -0.16, 1.03)} PhaseDelay=UseScanAngle Phi=0deg Theta=theta_inc
  FloquetCima: Floquet Port Faces=Air_Domain.face(+z) NumModes=4 Modes{Mode1{CharImp=Zpi} Mode2{CharImp=Zpi} Mode3{CharImp=Zpi} Mode4{CharImp=Zpi}} PhaseDelay=UseScanAngle Phi=0deg Theta=theta_inc LatticeAVector{(-0.16, -0.16, 1.03) -> (0.16, -0.16, 1.03)} LatticeBVector{(-0.16, -0.16, 1.03) -> (-0.16, 0.16, 1.03)} ModesCalculator{Frequency=1GHz PhiStart=0deg PhiStop=0deg PhiStep=0deg ThetaStart=0deg ThetaStop=0deg ThetaStep=0deg} ModesList{Mode{ModeNumber=1 IndexM=0 IndexN=0 KC2=0 PropagationState=Undefined Attenuation=0 PolarizationState=TE AffectsRefinement} Mode{ModeNumber=2 IndexM=0 IndexN=0 KC2=0 PropagationState=Undefined Attenuation=0 PolarizationState=TM AffectsRefinement} Mode{ModeNumber=3 IndexM=-1 IndexN=0 KC2=385531421917553 PropagationState=Undefined Attenuation=1.7054704e+08 PolarizationState=TE AffectsRefinement} Mode{ModeNumber=4 IndexM=0 IndexN=-1 KC2=385531421917553 PropagationState=Undefined Attenuation=1.7054704e+08 PolarizationState=TE AffectsRefinement}}
  FloquetBaixo: Floquet Port Faces=Air_Domain.face(-z) NumModes=4 Modes{Mode1{CharImp=Zpi} Mode2{CharImp=Zpi} Mode3{CharImp=Zpi} Mode4{CharImp=Zpi}} PhaseDelay=UseScanAngle Phi=0deg Theta=theta_inc LatticeAVector{(-0.16, -0.16, -1) -> (0.16, -0.16, -1)} LatticeBVector{(-0.16, -0.16, -1) -> (-0.16, 0.16, -1)} ModesCalculator{Frequency=1GHz PhiStart=0deg PhiStop=0deg PhiStep=0deg ThetaStart=0deg ThetaStop=0deg ThetaStep=0deg} ModesList{Mode{ModeNumber=1 IndexM=0 IndexN=0 KC2=0 PropagationState=Undefined Attenuation=0 PolarizationState=TE AffectsRefinement} Mode{ModeNumber=2 IndexM=0 IndexN=0 KC2=0 PropagationState=Undefined Attenuation=0 PolarizationState=TM AffectsRefinement} Mode{ModeNumber=3 IndexM=-1 IndexN=0 KC2=385531421917553 PropagationState=Undefined Attenuation=1.7054704e+08 PolarizationState=TE AffectsRefinement} Mode{ModeNumber=4 IndexM=0 IndexN=-1 KC2=385531421917553 PropagationState=Undefined Attenuation=1.7054704e+08 PolarizationState=TE AffectsRefinement}}
setups:
  Setup1: HfssDriven Frequency=666.2THz MaxDeltaS=0.01 MaximumPasses=15 MinimumPasses=1 MinimumConvergedPasses=1 PercentRefinement=30 BasisOrder=1 PortAccuracy=2 DrivenSolverType="Direct Solver"
    sweep Varredura: 187.4THz to 666.2THz, 401 points; Type=Interpolating InterpTolerance=0.5 InterpMaxSolns=250 PassivityErrorTolerance=0.0001
source amplitudes:
  FloquetCima:1: 1W 0deg
  FloquetCima:2, FloquetCima:3, FloquetCima:4, FloquetBaixo:1..FloquetBaixo:4: 0W 0deg

design G1525_anelQ_quadrado_trilhas (HFSS, HFSS Modal Network, model units um)
variables:
  theta_inc = 0deg
geometry:
  Au_anelq [Au_JC] = box(corner=(-0.0825um, -0.0825um, 0um), size=(0.165um, 0.165um, 0.03um))
  Au_anelq_furo = box(corner=(-0.0365um, -0.0365um, 0um), size=(0.073um, 0.073um, 0.03um))
  Au_anelq.subtract(Au_anelq_furo)
  Au_quadrado = box(corner=(-0.023um, -0.023um, 0um), size=(0.046um, 0.046um, 0.03um))
  Au_trilha0 = box(corner=(0.013um, -0.0115um, 0um), size=(0.0465um, 0.023um, 0.03um))
  Au_trilha1 = box(corner=(-0.0595um, -0.0115um, 0um), size=(0.0465um, 0.023um, 0.03um))
  Au_trilha2 = box(corner=(-0.0115um, 0.013um, 0um), size=(0.023um, 0.0465um, 0.03um))
  Au_trilha3 = box(corner=(-0.0115um, -0.0595um, 0um), size=(0.023um, 0.0465um, 0.03um))
  Au_anelq.unite(Au_quadrado, Au_trilha0..Au_trilha3)
  Air_Domain [vacuum] = box(corner=(-0.16um, -0.16um, -1um), size=(0.32um, 0.32um, 2.03um))
  Au_anelq_1 = Au_anelq.copy()
  Air_Domain.subtract(Au_anelq_1)
boundaries and excitations:
  LatticePair_472FI1: Lattice Pair Faces=Air_Domain.face(-x, +x) CoordSysVector{(-0.16, -0.16, -1) -> (-0.16, -0.16, 1.03)} PhaseDelay=UseScanAngle Phi=0deg Theta=theta_inc
  LatticePair_NZOGDX: Lattice Pair Faces=Air_Domain.face(-y, +y) CoordSysVector{(0.16, -0.16, -1) -> (0.16, -0.16, 1.03)} PhaseDelay=UseScanAngle Phi=0deg Theta=theta_inc
  FloquetCima: Floquet Port Faces=Air_Domain.face(+z) NumModes=4 Modes{Mode1{CharImp=Zpi} Mode2{CharImp=Zpi} Mode3{CharImp=Zpi} Mode4{CharImp=Zpi}} PhaseDelay=UseScanAngle Phi=0deg Theta=theta_inc LatticeAVector{(-0.16, -0.16, 1.03) -> (0.16, -0.16, 1.03)} LatticeBVector{(-0.16, -0.16, 1.03) -> (-0.16, 0.16, 1.03)} ModesCalculator{Frequency=1GHz PhiStart=0deg PhiStop=0deg PhiStep=0deg ThetaStart=0deg ThetaStop=0deg ThetaStep=0deg} ModesList{Mode{ModeNumber=1 IndexM=0 IndexN=0 KC2=0 PropagationState=Undefined Attenuation=0 PolarizationState=TE AffectsRefinement} Mode{ModeNumber=2 IndexM=0 IndexN=0 KC2=0 PropagationState=Undefined Attenuation=0 PolarizationState=TM AffectsRefinement} Mode{ModeNumber=3 IndexM=-1 IndexN=0 KC2=385531421917553 PropagationState=Undefined Attenuation=1.7054704e+08 PolarizationState=TE AffectsRefinement} Mode{ModeNumber=4 IndexM=0 IndexN=-1 KC2=385531421917553 PropagationState=Undefined Attenuation=1.7054704e+08 PolarizationState=TE AffectsRefinement}}
  FloquetBaixo: Floquet Port Faces=Air_Domain.face(-z) NumModes=4 Modes{Mode1{CharImp=Zpi} Mode2{CharImp=Zpi} Mode3{CharImp=Zpi} Mode4{CharImp=Zpi}} PhaseDelay=UseScanAngle Phi=0deg Theta=theta_inc LatticeAVector{(-0.16, -0.16, -1) -> (0.16, -0.16, -1)} LatticeBVector{(-0.16, -0.16, -1) -> (-0.16, 0.16, -1)} ModesCalculator{Frequency=1GHz PhiStart=0deg PhiStop=0deg PhiStep=0deg ThetaStart=0deg ThetaStop=0deg ThetaStep=0deg} ModesList{Mode{ModeNumber=1 IndexM=0 IndexN=0 KC2=0 PropagationState=Undefined Attenuation=0 PolarizationState=TE AffectsRefinement} Mode{ModeNumber=2 IndexM=0 IndexN=0 KC2=0 PropagationState=Undefined Attenuation=0 PolarizationState=TM AffectsRefinement} Mode{ModeNumber=3 IndexM=-1 IndexN=0 KC2=385531421917553 PropagationState=Undefined Attenuation=1.7054704e+08 PolarizationState=TE AffectsRefinement} Mode{ModeNumber=4 IndexM=0 IndexN=-1 KC2=385531421917553 PropagationState=Undefined Attenuation=1.7054704e+08 PolarizationState=TE AffectsRefinement}}
setups:
  Setup1: HfssDriven Frequency=666.2THz MaxDeltaS=0.01 MaximumPasses=15 MinimumPasses=1 MinimumConvergedPasses=1 PercentRefinement=30 BasisOrder=1 PortAccuracy=2 DrivenSolverType="Direct Solver"
    sweep Varredura: 187.4THz to 666.2THz, 401 points; Type=Interpolating InterpTolerance=0.5 InterpMaxSolns=250 PassivityErrorTolerance=0.0001
source amplitudes:
  FloquetCima:1: 1W 0deg
  FloquetCima:2, FloquetCima:3, FloquetCima:4, FloquetBaixo:1..FloquetBaixo:4: 0W 0deg

design G1499_anelQ_quadrado_trilhas (HFSS, HFSS Modal Network, model units um)
variables:
  theta_inc = 0deg
geometry:
  Au_anelq [Au_JC] = box(corner=(-0.097um, -0.097um, 0um), size=(0.194um, 0.194um, 0.03um))
  Au_anelq_furo = box(corner=(-0.051um, -0.051um, 0um), size=(0.102um, 0.102um, 0.03um))
  Au_anelq.subtract(Au_anelq_furo)
  Au_quadrado = box(corner=(-0.021um, -0.021um, 0um), size=(0.042um, 0.042um, 0.03um))
  Au_trilha0 = box(corner=(0.011um, -0.0145um, 0um), size=(0.063um, 0.029um, 0.03um))
  Au_trilha1 = box(corner=(-0.074um, -0.0145um, 0um), size=(0.063um, 0.029um, 0.03um))
  Au_trilha2 = box(corner=(-0.0145um, 0.011um, 0um), size=(0.029um, 0.063um, 0.03um))
  Au_trilha3 = box(corner=(-0.0145um, -0.074um, 0um), size=(0.029um, 0.063um, 0.03um))
  Au_anelq.unite(Au_quadrado, Au_trilha0..Au_trilha3)
  Air_Domain [vacuum] = box(corner=(-0.16um, -0.16um, -1um), size=(0.32um, 0.32um, 2.03um))
  Au_anelq_1 = Au_anelq.copy()
  Air_Domain.subtract(Au_anelq_1)
boundaries and excitations:
  LatticePair_N3QKTH: Lattice Pair Faces=Air_Domain.face(-x, +x) CoordSysVector{(-0.16, -0.16, -1) -> (-0.16, -0.16, 1.03)} PhaseDelay=UseScanAngle Phi=0deg Theta=theta_inc
  LatticePair_CBPUUJ: Lattice Pair Faces=Air_Domain.face(-y, +y) CoordSysVector{(0.16, -0.16, -1) -> (0.16, -0.16, 1.03)} PhaseDelay=UseScanAngle Phi=0deg Theta=theta_inc
  FloquetCima: Floquet Port Faces=Air_Domain.face(+z) NumModes=4 Modes{Mode1{CharImp=Zpi} Mode2{CharImp=Zpi} Mode3{CharImp=Zpi} Mode4{CharImp=Zpi}} PhaseDelay=UseScanAngle Phi=0deg Theta=theta_inc LatticeAVector{(-0.16, -0.16, 1.03) -> (0.16, -0.16, 1.03)} LatticeBVector{(-0.16, -0.16, 1.03) -> (-0.16, 0.16, 1.03)} ModesCalculator{Frequency=1GHz PhiStart=0deg PhiStop=0deg PhiStep=0deg ThetaStart=0deg ThetaStop=0deg ThetaStep=0deg} ModesList{Mode{ModeNumber=1 IndexM=0 IndexN=0 KC2=0 PropagationState=Undefined Attenuation=0 PolarizationState=TE AffectsRefinement} Mode{ModeNumber=2 IndexM=0 IndexN=0 KC2=0 PropagationState=Undefined Attenuation=0 PolarizationState=TM AffectsRefinement} Mode{ModeNumber=3 IndexM=-1 IndexN=0 KC2=385531421917553 PropagationState=Undefined Attenuation=1.7054704e+08 PolarizationState=TE AffectsRefinement} Mode{ModeNumber=4 IndexM=0 IndexN=-1 KC2=385531421917553 PropagationState=Undefined Attenuation=1.7054704e+08 PolarizationState=TE AffectsRefinement}}
  FloquetBaixo: Floquet Port Faces=Air_Domain.face(-z) NumModes=4 Modes{Mode1{CharImp=Zpi} Mode2{CharImp=Zpi} Mode3{CharImp=Zpi} Mode4{CharImp=Zpi}} PhaseDelay=UseScanAngle Phi=0deg Theta=theta_inc LatticeAVector{(-0.16, -0.16, -1) -> (0.16, -0.16, -1)} LatticeBVector{(-0.16, -0.16, -1) -> (-0.16, 0.16, -1)} ModesCalculator{Frequency=1GHz PhiStart=0deg PhiStop=0deg PhiStep=0deg ThetaStart=0deg ThetaStop=0deg ThetaStep=0deg} ModesList{Mode{ModeNumber=1 IndexM=0 IndexN=0 KC2=0 PropagationState=Undefined Attenuation=0 PolarizationState=TE AffectsRefinement} Mode{ModeNumber=2 IndexM=0 IndexN=0 KC2=0 PropagationState=Undefined Attenuation=0 PolarizationState=TM AffectsRefinement} Mode{ModeNumber=3 IndexM=-1 IndexN=0 KC2=385531421917553 PropagationState=Undefined Attenuation=1.7054704e+08 PolarizationState=TE AffectsRefinement} Mode{ModeNumber=4 IndexM=0 IndexN=-1 KC2=385531421917553 PropagationState=Undefined Attenuation=1.7054704e+08 PolarizationState=TE AffectsRefinement}}
setups:
  Setup1: HfssDriven Frequency=666.2THz MaxDeltaS=0.01 MaximumPasses=15 MinimumPasses=1 MinimumConvergedPasses=1 PercentRefinement=30 BasisOrder=1 PortAccuracy=2 DrivenSolverType="Direct Solver"
    sweep Varredura: 187.4THz to 666.2THz, 401 points; Type=Interpolating InterpTolerance=0.5 InterpMaxSolns=250 PassivityErrorTolerance=0.0001
source amplitudes:
  FloquetCima:1: 1W 0deg
  FloquetCima:2, FloquetCima:3, FloquetCima:4, FloquetBaixo:1..FloquetBaixo:4: 0W 0deg

design G1416_anelQ_quadrado_trilhas (HFSS, HFSS Modal Network, model units um)
variables:
  theta_inc = 0deg
geometry:
  Au_anelq [Au_JC] = box(corner=(-0.097um, -0.097um, 0um), size=(0.194um, 0.194um, 0.03um))
  Au_anelq_furo = box(corner=(-0.058um, -0.058um, 0um), size=(0.116um, 0.116um, 0.03um))
  Au_anelq.subtract(Au_anelq_furo)
  Au_quadrado = box(corner=(-0.0345um, -0.0345um, 0um), size=(0.069um, 0.069um, 0.03um))
  Au_trilha0 = box(corner=(0.0245um, -0.0135um, 0um), size=(0.053um, 0.027um, 0.03um))
  Au_trilha1 = box(corner=(-0.0775um, -0.0135um, 0um), size=(0.053um, 0.027um, 0.03um))
  Au_trilha2 = box(corner=(-0.0135um, 0.0245um, 0um), size=(0.027um, 0.053um, 0.03um))
  Au_trilha3 = box(corner=(-0.0135um, -0.0775um, 0um), size=(0.027um, 0.053um, 0.03um))
  Au_anelq.unite(Au_quadrado, Au_trilha0..Au_trilha3)
  Air_Domain [vacuum] = box(corner=(-0.16um, -0.16um, -1um), size=(0.32um, 0.32um, 2.03um))
  Au_anelq_1 = Au_anelq.copy()
  Air_Domain.subtract(Au_anelq_1)
boundaries and excitations:
  LatticePair_7Z980Y: Lattice Pair Faces=Air_Domain.face(-x, +x) CoordSysVector{(-0.16, -0.16, -1) -> (-0.16, -0.16, 1.03)} PhaseDelay=UseScanAngle Phi=0deg Theta=theta_inc
  LatticePair_UWM3KQ: Lattice Pair Faces=Air_Domain.face(-y, +y) CoordSysVector{(0.16, -0.16, -1) -> (0.16, -0.16, 1.03)} PhaseDelay=UseScanAngle Phi=0deg Theta=theta_inc
  FloquetCima: Floquet Port Faces=Air_Domain.face(+z) NumModes=4 Modes{Mode1{CharImp=Zpi} Mode2{CharImp=Zpi} Mode3{CharImp=Zpi} Mode4{CharImp=Zpi}} PhaseDelay=UseScanAngle Phi=0deg Theta=theta_inc LatticeAVector{(-0.16, -0.16, 1.03) -> (0.16, -0.16, 1.03)} LatticeBVector{(-0.16, -0.16, 1.03) -> (-0.16, 0.16, 1.03)} ModesCalculator{Frequency=1GHz PhiStart=0deg PhiStop=0deg PhiStep=0deg ThetaStart=0deg ThetaStop=0deg ThetaStep=0deg} ModesList{Mode{ModeNumber=1 IndexM=0 IndexN=0 KC2=0 PropagationState=Undefined Attenuation=0 PolarizationState=TE AffectsRefinement} Mode{ModeNumber=2 IndexM=0 IndexN=0 KC2=0 PropagationState=Undefined Attenuation=0 PolarizationState=TM AffectsRefinement} Mode{ModeNumber=3 IndexM=-1 IndexN=0 KC2=385531421917553 PropagationState=Undefined Attenuation=1.7054704e+08 PolarizationState=TE AffectsRefinement} Mode{ModeNumber=4 IndexM=0 IndexN=-1 KC2=385531421917553 PropagationState=Undefined Attenuation=1.7054704e+08 PolarizationState=TE AffectsRefinement}}
  FloquetBaixo: Floquet Port Faces=Air_Domain.face(-z) NumModes=4 Modes{Mode1{CharImp=Zpi} Mode2{CharImp=Zpi} Mode3{CharImp=Zpi} Mode4{CharImp=Zpi}} PhaseDelay=UseScanAngle Phi=0deg Theta=theta_inc LatticeAVector{(-0.16, -0.16, -1) -> (0.16, -0.16, -1)} LatticeBVector{(-0.16, -0.16, -1) -> (-0.16, 0.16, -1)} ModesCalculator{Frequency=1GHz PhiStart=0deg PhiStop=0deg PhiStep=0deg ThetaStart=0deg ThetaStop=0deg ThetaStep=0deg} ModesList{Mode{ModeNumber=1 IndexM=0 IndexN=0 KC2=0 PropagationState=Undefined Attenuation=0 PolarizationState=TE AffectsRefinement} Mode{ModeNumber=2 IndexM=0 IndexN=0 KC2=0 PropagationState=Undefined Attenuation=0 PolarizationState=TM AffectsRefinement} Mode{ModeNumber=3 IndexM=-1 IndexN=0 KC2=385531421917553 PropagationState=Undefined Attenuation=1.7054704e+08 PolarizationState=TE AffectsRefinement} Mode{ModeNumber=4 IndexM=0 IndexN=-1 KC2=385531421917553 PropagationState=Undefined Attenuation=1.7054704e+08 PolarizationState=TE AffectsRefinement}}
setups:
  Setup1: HfssDriven Frequency=666.2THz MaxDeltaS=0.01 MaximumPasses=15 MinimumPasses=1 MinimumConvergedPasses=1 PercentRefinement=30 BasisOrder=1 PortAccuracy=2 DrivenSolverType="Direct Solver"
    sweep Varredura: 187.4THz to 666.2THz, 401 points; Type=Interpolating InterpTolerance=0.5 InterpMaxSolns=250 PassivityErrorTolerance=0.0001
source amplitudes:
  FloquetCima:1: 1W 0deg
  FloquetCima:2, FloquetCima:3, FloquetCima:4, FloquetBaixo:1..FloquetBaixo:4: 0W 0deg

design G1549_anelQ_quadrado_trilhas (HFSS, HFSS Modal Network, model units um)
variables:
  theta_inc = 0deg
geometry:
  Au_anelq [Au_JC] = box(corner=(-0.1085um, -0.1085um, 0um), size=(0.217um, 0.217um, 0.03um))
  Au_anelq_furo = box(corner=(-0.0715um, -0.0715um, 0um), size=(0.143um, 0.143um, 0.03um))
  Au_anelq.subtract(Au_anelq_furo)
  Au_quadrado = box(corner=(-0.021um, -0.021um, 0um), size=(0.042um, 0.042um, 0.03um))
  Au_trilha0 = box(corner=(0.011um, -0.012um, 0um), size=(0.079um, 0.024um, 0.03um))
  Au_trilha1 = box(corner=(-0.09um, -0.012um, 0um), size=(0.079um, 0.024um, 0.03um))
  Au_trilha2 = box(corner=(-0.012um, 0.011um, 0um), size=(0.024um, 0.079um, 0.03um))
  Au_trilha3 = box(corner=(-0.012um, -0.09um, 0um), size=(0.024um, 0.079um, 0.03um))
  Au_anelq.unite(Au_quadrado, Au_trilha0..Au_trilha3)
  Air_Domain [vacuum] = box(corner=(-0.16um, -0.16um, -1um), size=(0.32um, 0.32um, 2.03um))
  Au_anelq_1 = Au_anelq.copy()
  Air_Domain.subtract(Au_anelq_1)
boundaries and excitations:
  LatticePair_D3JTZ9: Lattice Pair Faces=Air_Domain.face(-x, +x) CoordSysVector{(-0.16, -0.16, -1) -> (-0.16, -0.16, 1.03)} PhaseDelay=UseScanAngle Phi=0deg Theta=theta_inc
  LatticePair_DC2E2X: Lattice Pair Faces=Air_Domain.face(-y, +y) CoordSysVector{(0.16, -0.16, -1) -> (0.16, -0.16, 1.03)} PhaseDelay=UseScanAngle Phi=0deg Theta=theta_inc
  FloquetCima: Floquet Port Faces=Air_Domain.face(+z) NumModes=4 Modes{Mode1{CharImp=Zpi} Mode2{CharImp=Zpi} Mode3{CharImp=Zpi} Mode4{CharImp=Zpi}} PhaseDelay=UseScanAngle Phi=0deg Theta=theta_inc LatticeAVector{(-0.16, -0.16, 1.03) -> (0.16, -0.16, 1.03)} LatticeBVector{(-0.16, -0.16, 1.03) -> (-0.16, 0.16, 1.03)} ModesCalculator{Frequency=1GHz PhiStart=0deg PhiStop=0deg PhiStep=0deg ThetaStart=0deg ThetaStop=0deg ThetaStep=0deg} ModesList{Mode{ModeNumber=1 IndexM=0 IndexN=0 KC2=0 PropagationState=Undefined Attenuation=0 PolarizationState=TE AffectsRefinement} Mode{ModeNumber=2 IndexM=0 IndexN=0 KC2=0 PropagationState=Undefined Attenuation=0 PolarizationState=TM AffectsRefinement} Mode{ModeNumber=3 IndexM=-1 IndexN=0 KC2=385531421917553 PropagationState=Undefined Attenuation=1.7054704e+08 PolarizationState=TE AffectsRefinement} Mode{ModeNumber=4 IndexM=0 IndexN=-1 KC2=385531421917553 PropagationState=Undefined Attenuation=1.7054704e+08 PolarizationState=TE AffectsRefinement}}
  FloquetBaixo: Floquet Port Faces=Air_Domain.face(-z) NumModes=4 Modes{Mode1{CharImp=Zpi} Mode2{CharImp=Zpi} Mode3{CharImp=Zpi} Mode4{CharImp=Zpi}} PhaseDelay=UseScanAngle Phi=0deg Theta=theta_inc LatticeAVector{(-0.16, -0.16, -1) -> (0.16, -0.16, -1)} LatticeBVector{(-0.16, -0.16, -1) -> (-0.16, 0.16, -1)} ModesCalculator{Frequency=1GHz PhiStart=0deg PhiStop=0deg PhiStep=0deg ThetaStart=0deg ThetaStop=0deg ThetaStep=0deg} ModesList{Mode{ModeNumber=1 IndexM=0 IndexN=0 KC2=0 PropagationState=Undefined Attenuation=0 PolarizationState=TE AffectsRefinement} Mode{ModeNumber=2 IndexM=0 IndexN=0 KC2=0 PropagationState=Undefined Attenuation=0 PolarizationState=TM AffectsRefinement} Mode{ModeNumber=3 IndexM=-1 IndexN=0 KC2=385531421917553 PropagationState=Undefined Attenuation=1.7054704e+08 PolarizationState=TE AffectsRefinement} Mode{ModeNumber=4 IndexM=0 IndexN=-1 KC2=385531421917553 PropagationState=Undefined Attenuation=1.7054704e+08 PolarizationState=TE AffectsRefinement}}
setups:
  Setup1: HfssDriven Frequency=666.2THz MaxDeltaS=0.01 MaximumPasses=15 MinimumPasses=1 MinimumConvergedPasses=1 PercentRefinement=30 BasisOrder=1 PortAccuracy=2 DrivenSolverType="Direct Solver"
    sweep Varredura: 187.4THz to 666.2THz, 401 points; Type=Interpolating InterpTolerance=0.5 InterpMaxSolns=250 PassivityErrorTolerance=0.0001
source amplitudes:
  FloquetCima:1: 1W 0deg
  FloquetCima:2, FloquetCima:3, FloquetCima:4, FloquetBaixo:1..FloquetBaixo:4: 0W 0deg

design G1599_anelQ_quadrado_trilhas (HFSS, HFSS Modal Network, model units um)
variables:
  theta_inc = 0deg
geometry:
  Au_anelq [Au_JC] = box(corner=(-0.1175um, -0.1175um, 0um), size=(0.235um, 0.235um, 0.03um))
  Au_anelq_furo = box(corner=(-0.0905um, -0.0905um, 0um), size=(0.181um, 0.181um, 0.03um))
  Au_anelq.subtract(Au_anelq_furo)
  Au_quadrado = box(corner=(-0.066um, -0.066um, 0um), size=(0.132um, 0.132um, 0.03um))
  Au_trilha0 = box(corner=(0.056um, -0.014um, 0um), size=(0.048um, 0.028um, 0.03um))
  Au_trilha1 = box(corner=(-0.104um, -0.014um, 0um), size=(0.048um, 0.028um, 0.03um))
  Au_trilha2 = box(corner=(-0.014um, 0.056um, 0um), size=(0.028um, 0.048um, 0.03um))
  Au_trilha3 = box(corner=(-0.014um, -0.104um, 0um), size=(0.028um, 0.048um, 0.03um))
  Au_anelq.unite(Au_quadrado, Au_trilha0..Au_trilha3)
  Air_Domain [vacuum] = box(corner=(-0.16um, -0.16um, -1um), size=(0.32um, 0.32um, 2.03um))
  Au_anelq_1 = Au_anelq.copy()
  Air_Domain.subtract(Au_anelq_1)
boundaries and excitations:
  LatticePair_TAVJAT: Lattice Pair Faces=Air_Domain.face(-x, +x) CoordSysVector{(-0.16, -0.16, -1) -> (-0.16, -0.16, 1.03)} PhaseDelay=UseScanAngle Phi=0deg Theta=theta_inc
  LatticePair_KI1R1L: Lattice Pair Faces=Air_Domain.face(-y, +y) CoordSysVector{(0.16, -0.16, -1) -> (0.16, -0.16, 1.03)} PhaseDelay=UseScanAngle Phi=0deg Theta=theta_inc
  FloquetCima: Floquet Port Faces=Air_Domain.face(+z) NumModes=4 Modes{Mode1{CharImp=Zpi} Mode2{CharImp=Zpi} Mode3{CharImp=Zpi} Mode4{CharImp=Zpi}} PhaseDelay=UseScanAngle Phi=0deg Theta=theta_inc LatticeAVector{(-0.16, -0.16, 1.03) -> (0.16, -0.16, 1.03)} LatticeBVector{(-0.16, -0.16, 1.03) -> (-0.16, 0.16, 1.03)} ModesCalculator{Frequency=1GHz PhiStart=0deg PhiStop=0deg PhiStep=0deg ThetaStart=0deg ThetaStop=0deg ThetaStep=0deg} ModesList{Mode{ModeNumber=1 IndexM=0 IndexN=0 KC2=0 PropagationState=Undefined Attenuation=0 PolarizationState=TE AffectsRefinement} Mode{ModeNumber=2 IndexM=0 IndexN=0 KC2=0 PropagationState=Undefined Attenuation=0 PolarizationState=TM AffectsRefinement} Mode{ModeNumber=3 IndexM=-1 IndexN=0 KC2=385531421917553 PropagationState=Undefined Attenuation=1.7054704e+08 PolarizationState=TE AffectsRefinement} Mode{ModeNumber=4 IndexM=0 IndexN=-1 KC2=385531421917553 PropagationState=Undefined Attenuation=1.7054704e+08 PolarizationState=TE AffectsRefinement}}
  FloquetBaixo: Floquet Port Faces=Air_Domain.face(-z) NumModes=4 Modes{Mode1{CharImp=Zpi} Mode2{CharImp=Zpi} Mode3{CharImp=Zpi} Mode4{CharImp=Zpi}} PhaseDelay=UseScanAngle Phi=0deg Theta=theta_inc LatticeAVector{(-0.16, -0.16, -1) -> (0.16, -0.16, -1)} LatticeBVector{(-0.16, -0.16, -1) -> (-0.16, 0.16, -1)} ModesCalculator{Frequency=1GHz PhiStart=0deg PhiStop=0deg PhiStep=0deg ThetaStart=0deg ThetaStop=0deg ThetaStep=0deg} ModesList{Mode{ModeNumber=1 IndexM=0 IndexN=0 KC2=0 PropagationState=Undefined Attenuation=0 PolarizationState=TE AffectsRefinement} Mode{ModeNumber=2 IndexM=0 IndexN=0 KC2=0 PropagationState=Undefined Attenuation=0 PolarizationState=TM AffectsRefinement} Mode{ModeNumber=3 IndexM=-1 IndexN=0 KC2=385531421917553 PropagationState=Undefined Attenuation=1.7054704e+08 PolarizationState=TE AffectsRefinement} Mode{ModeNumber=4 IndexM=0 IndexN=-1 KC2=385531421917553 PropagationState=Undefined Attenuation=1.7054704e+08 PolarizationState=TE AffectsRefinement}}
setups:
  Setup1: HfssDriven Frequency=666.2THz MaxDeltaS=0.01 MaximumPasses=15 MinimumPasses=1 MinimumConvergedPasses=1 PercentRefinement=30 BasisOrder=1 PortAccuracy=2 DrivenSolverType="Direct Solver"
    sweep Varredura: 187.4THz to 666.2THz, 401 points; Type=Interpolating InterpTolerance=0.5 InterpMaxSolns=250 PassivityErrorTolerance=0.0001
source amplitudes:
  FloquetCima:1: 1W 0deg
  FloquetCima:2, FloquetCima:3, FloquetCima:4, FloquetBaixo:1..FloquetBaixo:4: 0W 0deg

design G1453_anelQ_quadrado_trilhas (HFSS, HFSS Modal Network, model units um)
variables:
  theta_inc = 0deg
geometry:
  Au_anelq [Au_JC] = box(corner=(-0.1025um, -0.1025um, 0um), size=(0.205um, 0.205um, 0.03um))
  Au_anelq_furo = box(corner=(-0.0705um, -0.0705um, 0um), size=(0.141um, 0.141um, 0.03um))
  Au_anelq.subtract(Au_anelq_furo)
  Au_quadrado = box(corner=(-0.06um, -0.06um, 0um), size=(0.12um, 0.12um, 0.03um))
  Au_trilha0 = box(corner=(0.05um, -0.0125um, 0um), size=(0.0365um, 0.025um, 0.03um))
  Au_trilha1 = box(corner=(-0.0865um, -0.0125um, 0um), size=(0.0365um, 0.025um, 0.03um))
  Au_trilha2 = box(corner=(-0.0125um, 0.05um, 0um), size=(0.025um, 0.0365um, 0.03um))
  Au_trilha3 = box(corner=(-0.0125um, -0.0865um, 0um), size=(0.025um, 0.0365um, 0.03um))
  Au_anelq.unite(Au_quadrado, Au_trilha0..Au_trilha3)
  Air_Domain [vacuum] = box(corner=(-0.16um, -0.16um, -1um), size=(0.32um, 0.32um, 2.03um))
  Au_anelq_1 = Au_anelq.copy()
  Air_Domain.subtract(Au_anelq_1)
boundaries and excitations:
  LatticePair_97ONFB: Lattice Pair Faces=Air_Domain.face(-x, +x) CoordSysVector{(-0.16, -0.16, -1) -> (-0.16, -0.16, 1.03)} PhaseDelay=UseScanAngle Phi=0deg Theta=theta_inc
  LatticePair_OJ2YIA: Lattice Pair Faces=Air_Domain.face(-y, +y) CoordSysVector{(0.16, -0.16, -1) -> (0.16, -0.16, 1.03)} PhaseDelay=UseScanAngle Phi=0deg Theta=theta_inc
  FloquetCima: Floquet Port Faces=Air_Domain.face(+z) NumModes=4 Modes{Mode1{CharImp=Zpi} Mode2{CharImp=Zpi} Mode3{CharImp=Zpi} Mode4{CharImp=Zpi}} PhaseDelay=UseScanAngle Phi=0deg Theta=theta_inc LatticeAVector{(-0.16, -0.16, 1.03) -> (0.16, -0.16, 1.03)} LatticeBVector{(-0.16, -0.16, 1.03) -> (-0.16, 0.16, 1.03)} ModesCalculator{Frequency=1GHz PhiStart=0deg PhiStop=0deg PhiStep=0deg ThetaStart=0deg ThetaStop=0deg ThetaStep=0deg} ModesList{Mode{ModeNumber=1 IndexM=0 IndexN=0 KC2=0 PropagationState=Undefined Attenuation=0 PolarizationState=TE AffectsRefinement} Mode{ModeNumber=2 IndexM=0 IndexN=0 KC2=0 PropagationState=Undefined Attenuation=0 PolarizationState=TM AffectsRefinement} Mode{ModeNumber=3 IndexM=-1 IndexN=0 KC2=385531421917553 PropagationState=Undefined Attenuation=1.7054704e+08 PolarizationState=TE AffectsRefinement} Mode{ModeNumber=4 IndexM=0 IndexN=-1 KC2=385531421917553 PropagationState=Undefined Attenuation=1.7054704e+08 PolarizationState=TE AffectsRefinement}}
  FloquetBaixo: Floquet Port Faces=Air_Domain.face(-z) NumModes=4 Modes{Mode1{CharImp=Zpi} Mode2{CharImp=Zpi} Mode3{CharImp=Zpi} Mode4{CharImp=Zpi}} PhaseDelay=UseScanAngle Phi=0deg Theta=theta_inc LatticeAVector{(-0.16, -0.16, -1) -> (0.16, -0.16, -1)} LatticeBVector{(-0.16, -0.16, -1) -> (-0.16, 0.16, -1)} ModesCalculator{Frequency=1GHz PhiStart=0deg PhiStop=0deg PhiStep=0deg ThetaStart=0deg ThetaStop=0deg ThetaStep=0deg} ModesList{Mode{ModeNumber=1 IndexM=0 IndexN=0 KC2=0 PropagationState=Undefined Attenuation=0 PolarizationState=TE AffectsRefinement} Mode{ModeNumber=2 IndexM=0 IndexN=0 KC2=0 PropagationState=Undefined Attenuation=0 PolarizationState=TM AffectsRefinement} Mode{ModeNumber=3 IndexM=-1 IndexN=0 KC2=385531421917553 PropagationState=Undefined Attenuation=1.7054704e+08 PolarizationState=TE AffectsRefinement} Mode{ModeNumber=4 IndexM=0 IndexN=-1 KC2=385531421917553 PropagationState=Undefined Attenuation=1.7054704e+08 PolarizationState=TE AffectsRefinement}}
setups:
  Setup1: HfssDriven Frequency=666.2THz MaxDeltaS=0.01 MaximumPasses=15 MinimumPasses=1 MinimumConvergedPasses=1 PercentRefinement=30 BasisOrder=1 PortAccuracy=2 DrivenSolverType="Direct Solver"
    sweep Varredura: 187.4THz to 666.2THz, 401 points; Type=Interpolating InterpTolerance=0.5 InterpMaxSolns=250 PassivityErrorTolerance=0.0001
source amplitudes:
  FloquetCima:1: 1W 0deg
  FloquetCima:2, FloquetCima:3, FloquetCima:4, FloquetBaixo:1..FloquetBaixo:4: 0W 0deg

design G1458_anelQ_quadrado_trilhas (HFSS, HFSS Modal Network, model units um)
variables:
  theta_inc = 0deg
geometry:
  Au_anelq [Au_JC] = box(corner=(-0.094um, -0.094um, 0um), size=(0.188um, 0.188um, 0.03um))
  Au_anelq_furo = box(corner=(-0.048um, -0.048um, 0um), size=(0.096um, 0.096um, 0.03um))
  Au_anelq.subtract(Au_anelq_furo)
  Au_quadrado = box(corner=(-0.026um, -0.026um, 0um), size=(0.052um, 0.052um, 0.03um))
  Au_trilha0 = box(corner=(0.016um, -0.0105um, 0um), size=(0.055um, 0.021um, 0.03um))
  Au_trilha1 = box(corner=(-0.071um, -0.0105um, 0um), size=(0.055um, 0.021um, 0.03um))
  Au_trilha2 = box(corner=(-0.0105um, 0.016um, 0um), size=(0.021um, 0.055um, 0.03um))
  Au_trilha3 = box(corner=(-0.0105um, -0.071um, 0um), size=(0.021um, 0.055um, 0.03um))
  Au_anelq.unite(Au_quadrado, Au_trilha0..Au_trilha3)
  Air_Domain [vacuum] = box(corner=(-0.16um, -0.16um, -1um), size=(0.32um, 0.32um, 2.03um))
  Au_anelq_1 = Au_anelq.copy()
  Air_Domain.subtract(Au_anelq_1)
boundaries and excitations:
  LatticePair_X0VWSN: Lattice Pair Faces=Air_Domain.face(-x, +x) CoordSysVector{(-0.16, -0.16, -1) -> (-0.16, -0.16, 1.03)} PhaseDelay=UseScanAngle Phi=0deg Theta=theta_inc
  LatticePair_JGWSF9: Lattice Pair Faces=Air_Domain.face(-y, +y) CoordSysVector{(0.16, -0.16, -1) -> (0.16, -0.16, 1.03)} PhaseDelay=UseScanAngle Phi=0deg Theta=theta_inc
  FloquetCima: Floquet Port Faces=Air_Domain.face(+z) NumModes=4 Modes{Mode1{CharImp=Zpi} Mode2{CharImp=Zpi} Mode3{CharImp=Zpi} Mode4{CharImp=Zpi}} PhaseDelay=UseScanAngle Phi=0deg Theta=theta_inc LatticeAVector{(-0.16, -0.16, 1.03) -> (0.16, -0.16, 1.03)} LatticeBVector{(-0.16, -0.16, 1.03) -> (-0.16, 0.16, 1.03)} ModesCalculator{Frequency=1GHz PhiStart=0deg PhiStop=0deg PhiStep=0deg ThetaStart=0deg ThetaStop=0deg ThetaStep=0deg} ModesList{Mode{ModeNumber=1 IndexM=0 IndexN=0 KC2=0 PropagationState=Undefined Attenuation=0 PolarizationState=TE AffectsRefinement} Mode{ModeNumber=2 IndexM=0 IndexN=0 KC2=0 PropagationState=Undefined Attenuation=0 PolarizationState=TM AffectsRefinement} Mode{ModeNumber=3 IndexM=-1 IndexN=0 KC2=385531421917553 PropagationState=Undefined Attenuation=1.7054704e+08 PolarizationState=TE AffectsRefinement} Mode{ModeNumber=4 IndexM=0 IndexN=-1 KC2=385531421917553 PropagationState=Undefined Attenuation=1.7054704e+08 PolarizationState=TE AffectsRefinement}}
  FloquetBaixo: Floquet Port Faces=Air_Domain.face(-z) NumModes=4 Modes{Mode1{CharImp=Zpi} Mode2{CharImp=Zpi} Mode3{CharImp=Zpi} Mode4{CharImp=Zpi}} PhaseDelay=UseScanAngle Phi=0deg Theta=theta_inc LatticeAVector{(-0.16, -0.16, -1) -> (0.16, -0.16, -1)} LatticeBVector{(-0.16, -0.16, -1) -> (-0.16, 0.16, -1)} ModesCalculator{Frequency=1GHz PhiStart=0deg PhiStop=0deg PhiStep=0deg ThetaStart=0deg ThetaStop=0deg ThetaStep=0deg} ModesList{Mode{ModeNumber=1 IndexM=0 IndexN=0 KC2=0 PropagationState=Undefined Attenuation=0 PolarizationState=TE AffectsRefinement} Mode{ModeNumber=2 IndexM=0 IndexN=0 KC2=0 PropagationState=Undefined Attenuation=0 PolarizationState=TM AffectsRefinement} Mode{ModeNumber=3 IndexM=-1 IndexN=0 KC2=385531421917553 PropagationState=Undefined Attenuation=1.7054704e+08 PolarizationState=TE AffectsRefinement} Mode{ModeNumber=4 IndexM=0 IndexN=-1 KC2=385531421917553 PropagationState=Undefined Attenuation=1.7054704e+08 PolarizationState=TE AffectsRefinement}}
setups:
  Setup1: HfssDriven Frequency=666.2THz MaxDeltaS=0.01 MaximumPasses=15 MinimumPasses=1 MinimumConvergedPasses=1 PercentRefinement=30 BasisOrder=1 PortAccuracy=2 DrivenSolverType="Direct Solver"
    sweep Varredura: 187.4THz to 666.2THz, 401 points; Type=Interpolating InterpTolerance=0.5 InterpMaxSolns=250 PassivityErrorTolerance=0.0001
source amplitudes:
  FloquetCima:1: 1W 0deg
  FloquetCima:2, FloquetCima:3, FloquetCima:4, FloquetBaixo:1..FloquetBaixo:4: 0W 0deg

design G1706_anelC_disco (HFSS, HFSS Modal Network, model units um)
variables:
  theta_inc = 0deg
geometry:
  Au_anelc [Au_JC] = cylinder(axis=Z, base_centre=(0um, 0um, 0um), radius=0.088um, height=0.03um)
  Au_anelc_furo = cylinder(axis=Z, base_centre=(0um, 0um, 0um), radius=0.053um, height=0.03um)
  Au_anelc.subtract(Au_anelc_furo)
  Au_disco = cylinder(axis=Z, base_centre=(0um, 0um, 0um), radius=0.023um, height=0.03um)
  Au_anelc.unite(Au_disco)
  Air_Domain [vacuum] = box(corner=(-0.16um, -0.16um, -1um), size=(0.32um, 0.32um, 2.03um))
  Au_anelc_1 = Au_anelc.copy()
  Air_Domain.subtract(Au_anelc_1)
boundaries and excitations:
  LatticePair_C9H4N3: Lattice Pair Faces=Air_Domain.face(-x, +x) CoordSysVector{(-0.16, -0.16, -1) -> (-0.16, -0.16, 1.03)} PhaseDelay=UseScanAngle Phi=0deg Theta=theta_inc
  LatticePair_30052M: Lattice Pair Faces=Air_Domain.face(-y, +y) CoordSysVector{(0.16, -0.16, -1) -> (0.16, -0.16, 1.03)} PhaseDelay=UseScanAngle Phi=0deg Theta=theta_inc
  FloquetCima: Floquet Port Faces=Air_Domain.face(+z) NumModes=4 Modes{Mode1{CharImp=Zpi} Mode2{CharImp=Zpi} Mode3{CharImp=Zpi} Mode4{CharImp=Zpi}} PhaseDelay=UseScanAngle Phi=0deg Theta=theta_inc LatticeAVector{(-0.16, -0.16, 1.03) -> (0.16, -0.16, 1.03)} LatticeBVector{(-0.16, -0.16, 1.03) -> (-0.16, 0.16, 1.03)} ModesCalculator{Frequency=1GHz PhiStart=0deg PhiStop=0deg PhiStep=0deg ThetaStart=0deg ThetaStop=0deg ThetaStep=0deg} ModesList{Mode{ModeNumber=1 IndexM=0 IndexN=0 KC2=0 PropagationState=Undefined Attenuation=0 PolarizationState=TE AffectsRefinement} Mode{ModeNumber=2 IndexM=0 IndexN=0 KC2=0 PropagationState=Undefined Attenuation=0 PolarizationState=TM AffectsRefinement} Mode{ModeNumber=3 IndexM=-1 IndexN=0 KC2=385531421917553 PropagationState=Undefined Attenuation=1.7054704e+08 PolarizationState=TE AffectsRefinement} Mode{ModeNumber=4 IndexM=0 IndexN=-1 KC2=385531421917553 PropagationState=Undefined Attenuation=1.7054704e+08 PolarizationState=TE AffectsRefinement}}
  FloquetBaixo: Floquet Port Faces=Air_Domain.face(-z) NumModes=4 Modes{Mode1{CharImp=Zpi} Mode2{CharImp=Zpi} Mode3{CharImp=Zpi} Mode4{CharImp=Zpi}} PhaseDelay=UseScanAngle Phi=0deg Theta=theta_inc LatticeAVector{(-0.16, -0.16, -1) -> (0.16, -0.16, -1)} LatticeBVector{(-0.16, -0.16, -1) -> (-0.16, 0.16, -1)} ModesCalculator{Frequency=1GHz PhiStart=0deg PhiStop=0deg PhiStep=0deg ThetaStart=0deg ThetaStop=0deg ThetaStep=0deg} ModesList{Mode{ModeNumber=1 IndexM=0 IndexN=0 KC2=0 PropagationState=Undefined Attenuation=0 PolarizationState=TE AffectsRefinement} Mode{ModeNumber=2 IndexM=0 IndexN=0 KC2=0 PropagationState=Undefined Attenuation=0 PolarizationState=TM AffectsRefinement} Mode{ModeNumber=3 IndexM=-1 IndexN=0 KC2=385531421917553 PropagationState=Undefined Attenuation=1.7054704e+08 PolarizationState=TE AffectsRefinement} Mode{ModeNumber=4 IndexM=0 IndexN=-1 KC2=385531421917553 PropagationState=Undefined Attenuation=1.7054704e+08 PolarizationState=TE AffectsRefinement}}
setups:
  Setup1: HfssDriven Frequency=666.2THz MaxDeltaS=0.01 MaximumPasses=15 MinimumPasses=1 MinimumConvergedPasses=1 PercentRefinement=30 BasisOrder=1 PortAccuracy=2 DrivenSolverType="Direct Solver"
    sweep Varredura: 187.4THz to 666.2THz, 401 points; Type=Interpolating InterpTolerance=0.5 InterpMaxSolns=250 PassivityErrorTolerance=0.0001
source amplitudes:
  FloquetCima:1: 1W 0deg
  FloquetCima:2, FloquetCima:3, FloquetCima:4, FloquetBaixo:1..FloquetBaixo:4: 0W 0deg

design G1781_anelC_disco (HFSS, HFSS Modal Network, model units um)
variables:
  theta_inc = 0deg
geometry:
  Au_anelc [Au_JC] = cylinder(axis=Z, base_centre=(0um, 0um, 0um), radius=0.083um, height=0.03um)
  Au_anelc_furo = cylinder(axis=Z, base_centre=(0um, 0um, 0um), radius=0.054um, height=0.03um)
  Au_anelc.subtract(Au_anelc_furo)
  Au_disco = cylinder(axis=Z, base_centre=(0um, 0um, 0um), radius=0.026um, height=0.03um)
  Au_anelc.unite(Au_disco)
  Air_Domain [vacuum] = box(corner=(-0.16um, -0.16um, -1um), size=(0.32um, 0.32um, 2.03um))
  Au_anelc_1 = Au_anelc.copy()
  Air_Domain.subtract(Au_anelc_1)
boundaries and excitations:
  LatticePair_MS1OWZ: Lattice Pair Faces=Air_Domain.face(-x, +x) CoordSysVector{(-0.16, -0.16, -1) -> (-0.16, -0.16, 1.03)} PhaseDelay=UseScanAngle Phi=0deg Theta=theta_inc
  LatticePair_ISCWUC: Lattice Pair Faces=Air_Domain.face(-y, +y) CoordSysVector{(0.16, -0.16, -1) -> (0.16, -0.16, 1.03)} PhaseDelay=UseScanAngle Phi=0deg Theta=theta_inc
  FloquetCima: Floquet Port Faces=Air_Domain.face(+z) NumModes=4 Modes{Mode1{CharImp=Zpi} Mode2{CharImp=Zpi} Mode3{CharImp=Zpi} Mode4{CharImp=Zpi}} PhaseDelay=UseScanAngle Phi=0deg Theta=theta_inc LatticeAVector{(-0.16, -0.16, 1.03) -> (0.16, -0.16, 1.03)} LatticeBVector{(-0.16, -0.16, 1.03) -> (-0.16, 0.16, 1.03)} ModesCalculator{Frequency=1GHz PhiStart=0deg PhiStop=0deg PhiStep=0deg ThetaStart=0deg ThetaStop=0deg ThetaStep=0deg} ModesList{Mode{ModeNumber=1 IndexM=0 IndexN=0 KC2=0 PropagationState=Undefined Attenuation=0 PolarizationState=TE AffectsRefinement} Mode{ModeNumber=2 IndexM=0 IndexN=0 KC2=0 PropagationState=Undefined Attenuation=0 PolarizationState=TM AffectsRefinement} Mode{ModeNumber=3 IndexM=-1 IndexN=0 KC2=385531421917553 PropagationState=Undefined Attenuation=1.7054704e+08 PolarizationState=TE AffectsRefinement} Mode{ModeNumber=4 IndexM=0 IndexN=-1 KC2=385531421917553 PropagationState=Undefined Attenuation=1.7054704e+08 PolarizationState=TE AffectsRefinement}}
  FloquetBaixo: Floquet Port Faces=Air_Domain.face(-z) NumModes=4 Modes{Mode1{CharImp=Zpi} Mode2{CharImp=Zpi} Mode3{CharImp=Zpi} Mode4{CharImp=Zpi}} PhaseDelay=UseScanAngle Phi=0deg Theta=theta_inc LatticeAVector{(-0.16, -0.16, -1) -> (0.16, -0.16, -1)} LatticeBVector{(-0.16, -0.16, -1) -> (-0.16, 0.16, -1)} ModesCalculator{Frequency=1GHz PhiStart=0deg PhiStop=0deg PhiStep=0deg ThetaStart=0deg ThetaStop=0deg ThetaStep=0deg} ModesList{Mode{ModeNumber=1 IndexM=0 IndexN=0 KC2=0 PropagationState=Undefined Attenuation=0 PolarizationState=TE AffectsRefinement} Mode{ModeNumber=2 IndexM=0 IndexN=0 KC2=0 PropagationState=Undefined Attenuation=0 PolarizationState=TM AffectsRefinement} Mode{ModeNumber=3 IndexM=-1 IndexN=0 KC2=385531421917553 PropagationState=Undefined Attenuation=1.7054704e+08 PolarizationState=TE AffectsRefinement} Mode{ModeNumber=4 IndexM=0 IndexN=-1 KC2=385531421917553 PropagationState=Undefined Attenuation=1.7054704e+08 PolarizationState=TE AffectsRefinement}}
setups:
  Setup1: HfssDriven Frequency=666.2THz MaxDeltaS=0.01 MaximumPasses=15 MinimumPasses=1 MinimumConvergedPasses=1 PercentRefinement=30 BasisOrder=1 PortAccuracy=2 DrivenSolverType="Direct Solver"
    sweep Varredura: 187.4THz to 666.2THz, 401 points; Type=Interpolating InterpTolerance=0.5 InterpMaxSolns=250 PassivityErrorTolerance=0.0001
source amplitudes:
  FloquetCima:1: 1W 0deg
  FloquetCima:2, FloquetCima:3, FloquetCima:4, FloquetBaixo:1..FloquetBaixo:4: 0W 0deg

design G1727_anelC_disco (HFSS, HFSS Modal Network, model units um)
variables:
  theta_inc = 0deg
geometry:
  Au_anelc [Au_JC] = cylinder(axis=Z, base_centre=(0um, 0um, 0um), radius=0.138um, height=0.03um)
  Au_anelc_furo = cylinder(axis=Z, base_centre=(0um, 0um, 0um), radius=0.094um, height=0.03um)
  Au_anelc.subtract(Au_anelc_furo)
  Au_disco = cylinder(axis=Z, base_centre=(0um, 0um, 0um), radius=0.071um, height=0.03um)
  Au_anelc.unite(Au_disco)
  Air_Domain [vacuum] = box(corner=(-0.16um, -0.16um, -1um), size=(0.32um, 0.32um, 2.03um))
  Au_anelc_1 = Au_anelc.copy()
  Air_Domain.subtract(Au_anelc_1)
boundaries and excitations:
  LatticePair_GAC1Z0: Lattice Pair Faces=Air_Domain.face(-x, +x) CoordSysVector{(-0.16, -0.16, -1) -> (-0.16, -0.16, 1.03)} PhaseDelay=UseScanAngle Phi=0deg Theta=theta_inc
  LatticePair_NZOPOO: Lattice Pair Faces=Air_Domain.face(-y, +y) CoordSysVector{(0.16, -0.16, -1) -> (0.16, -0.16, 1.03)} PhaseDelay=UseScanAngle Phi=0deg Theta=theta_inc
  FloquetCima: Floquet Port Faces=Air_Domain.face(+z) NumModes=4 Modes{Mode1{CharImp=Zpi} Mode2{CharImp=Zpi} Mode3{CharImp=Zpi} Mode4{CharImp=Zpi}} PhaseDelay=UseScanAngle Phi=0deg Theta=theta_inc LatticeAVector{(-0.16, -0.16, 1.03) -> (0.16, -0.16, 1.03)} LatticeBVector{(-0.16, -0.16, 1.03) -> (-0.16, 0.16, 1.03)} ModesCalculator{Frequency=1GHz PhiStart=0deg PhiStop=0deg PhiStep=0deg ThetaStart=0deg ThetaStop=0deg ThetaStep=0deg} ModesList{Mode{ModeNumber=1 IndexM=0 IndexN=0 KC2=0 PropagationState=Undefined Attenuation=0 PolarizationState=TE AffectsRefinement} Mode{ModeNumber=2 IndexM=0 IndexN=0 KC2=0 PropagationState=Undefined Attenuation=0 PolarizationState=TM AffectsRefinement} Mode{ModeNumber=3 IndexM=-1 IndexN=0 KC2=385531421917553 PropagationState=Undefined Attenuation=1.7054704e+08 PolarizationState=TE AffectsRefinement} Mode{ModeNumber=4 IndexM=0 IndexN=-1 KC2=385531421917553 PropagationState=Undefined Attenuation=1.7054704e+08 PolarizationState=TE AffectsRefinement}}
  FloquetBaixo: Floquet Port Faces=Air_Domain.face(-z) NumModes=4 Modes{Mode1{CharImp=Zpi} Mode2{CharImp=Zpi} Mode3{CharImp=Zpi} Mode4{CharImp=Zpi}} PhaseDelay=UseScanAngle Phi=0deg Theta=theta_inc LatticeAVector{(-0.16, -0.16, -1) -> (0.16, -0.16, -1)} LatticeBVector{(-0.16, -0.16, -1) -> (-0.16, 0.16, -1)} ModesCalculator{Frequency=1GHz PhiStart=0deg PhiStop=0deg PhiStep=0deg ThetaStart=0deg ThetaStop=0deg ThetaStep=0deg} ModesList{Mode{ModeNumber=1 IndexM=0 IndexN=0 KC2=0 PropagationState=Undefined Attenuation=0 PolarizationState=TE AffectsRefinement} Mode{ModeNumber=2 IndexM=0 IndexN=0 KC2=0 PropagationState=Undefined Attenuation=0 PolarizationState=TM AffectsRefinement} Mode{ModeNumber=3 IndexM=-1 IndexN=0 KC2=385531421917553 PropagationState=Undefined Attenuation=1.7054704e+08 PolarizationState=TE AffectsRefinement} Mode{ModeNumber=4 IndexM=0 IndexN=-1 KC2=385531421917553 PropagationState=Undefined Attenuation=1.7054704e+08 PolarizationState=TE AffectsRefinement}}
setups:
  Setup1: HfssDriven Frequency=666.2THz MaxDeltaS=0.01 MaximumPasses=15 MinimumPasses=1 MinimumConvergedPasses=1 PercentRefinement=30 BasisOrder=1 PortAccuracy=2 DrivenSolverType="Direct Solver"
    sweep Varredura: 187.4THz to 666.2THz, 401 points; Type=Interpolating InterpTolerance=0.5 InterpMaxSolns=250 PassivityErrorTolerance=0.0001
source amplitudes:
  FloquetCima:1: 1W 0deg
  FloquetCima:2, FloquetCima:3, FloquetCima:4, FloquetBaixo:1..FloquetBaixo:4: 0W 0deg

design G1726_anelC_disco (HFSS, HFSS Modal Network, model units um)
variables:
  theta_inc = 0deg
geometry:
  Au_anelc [Au_JC] = cylinder(axis=Z, base_centre=(0um, 0um, 0um), radius=0.14um, height=0.03um)
  Au_anelc_furo = cylinder(axis=Z, base_centre=(0um, 0um, 0um), radius=0.097um, height=0.03um)
  Au_anelc.subtract(Au_anelc_furo)
  Au_disco = cylinder(axis=Z, base_centre=(0um, 0um, 0um), radius=0.073um, height=0.03um)
  Au_anelc.unite(Au_disco)
  Air_Domain [vacuum] = box(corner=(-0.16um, -0.16um, -1um), size=(0.32um, 0.32um, 2.03um))
  Au_anelc_1 = Au_anelc.copy()
  Air_Domain.subtract(Au_anelc_1)
boundaries and excitations:
  LatticePair_IRQFRA: Lattice Pair Faces=Air_Domain.face(-x, +x) CoordSysVector{(-0.16, -0.16, -1) -> (-0.16, -0.16, 1.03)} PhaseDelay=UseScanAngle Phi=0deg Theta=theta_inc
  LatticePair_WWFGUE: Lattice Pair Faces=Air_Domain.face(-y, +y) CoordSysVector{(0.16, -0.16, -1) -> (0.16, -0.16, 1.03)} PhaseDelay=UseScanAngle Phi=0deg Theta=theta_inc
  FloquetCima: Floquet Port Faces=Air_Domain.face(+z) NumModes=4 Modes{Mode1{CharImp=Zpi} Mode2{CharImp=Zpi} Mode3{CharImp=Zpi} Mode4{CharImp=Zpi}} PhaseDelay=UseScanAngle Phi=0deg Theta=theta_inc LatticeAVector{(-0.16, -0.16, 1.03) -> (0.16, -0.16, 1.03)} LatticeBVector{(-0.16, -0.16, 1.03) -> (-0.16, 0.16, 1.03)} ModesCalculator{Frequency=1GHz PhiStart=0deg PhiStop=0deg PhiStep=0deg ThetaStart=0deg ThetaStop=0deg ThetaStep=0deg} ModesList{Mode{ModeNumber=1 IndexM=0 IndexN=0 KC2=0 PropagationState=Undefined Attenuation=0 PolarizationState=TE AffectsRefinement} Mode{ModeNumber=2 IndexM=0 IndexN=0 KC2=0 PropagationState=Undefined Attenuation=0 PolarizationState=TM AffectsRefinement} Mode{ModeNumber=3 IndexM=-1 IndexN=0 KC2=385531421917553 PropagationState=Undefined Attenuation=1.7054704e+08 PolarizationState=TE AffectsRefinement} Mode{ModeNumber=4 IndexM=0 IndexN=-1 KC2=385531421917553 PropagationState=Undefined Attenuation=1.7054704e+08 PolarizationState=TE AffectsRefinement}}
  FloquetBaixo: Floquet Port Faces=Air_Domain.face(-z) NumModes=4 Modes{Mode1{CharImp=Zpi} Mode2{CharImp=Zpi} Mode3{CharImp=Zpi} Mode4{CharImp=Zpi}} PhaseDelay=UseScanAngle Phi=0deg Theta=theta_inc LatticeAVector{(-0.16, -0.16, -1) -> (0.16, -0.16, -1)} LatticeBVector{(-0.16, -0.16, -1) -> (-0.16, 0.16, -1)} ModesCalculator{Frequency=1GHz PhiStart=0deg PhiStop=0deg PhiStep=0deg ThetaStart=0deg ThetaStop=0deg ThetaStep=0deg} ModesList{Mode{ModeNumber=1 IndexM=0 IndexN=0 KC2=0 PropagationState=Undefined Attenuation=0 PolarizationState=TE AffectsRefinement} Mode{ModeNumber=2 IndexM=0 IndexN=0 KC2=0 PropagationState=Undefined Attenuation=0 PolarizationState=TM AffectsRefinement} Mode{ModeNumber=3 IndexM=-1 IndexN=0 KC2=385531421917553 PropagationState=Undefined Attenuation=1.7054704e+08 PolarizationState=TE AffectsRefinement} Mode{ModeNumber=4 IndexM=0 IndexN=-1 KC2=385531421917553 PropagationState=Undefined Attenuation=1.7054704e+08 PolarizationState=TE AffectsRefinement}}
setups:
  Setup1: HfssDriven Frequency=666.2THz MaxDeltaS=0.01 MaximumPasses=15 MinimumPasses=1 MinimumConvergedPasses=1 PercentRefinement=30 BasisOrder=1 PortAccuracy=2 DrivenSolverType="Direct Solver"
    sweep Varredura: 187.4THz to 666.2THz, 401 points; Type=Interpolating InterpTolerance=0.5 InterpMaxSolns=250 PassivityErrorTolerance=0.0001
source amplitudes:
  FloquetCima:1: 1W 0deg
  FloquetCima:2, FloquetCima:3, FloquetCima:4, FloquetBaixo:1..FloquetBaixo:4: 0W 0deg

design G1605_anelC_disco (HFSS, HFSS Modal Network, model units um)
variables:
  theta_inc = 0deg
geometry:
  Au_anelc [Au_JC] = cylinder(axis=Z, base_centre=(0um, 0um, 0um), radius=0.086um, height=0.03um)
  Au_anelc_furo = cylinder(axis=Z, base_centre=(0um, 0um, 0um), radius=0.057um, height=0.03um)
  Au_anelc.subtract(Au_anelc_furo)
  Au_disco = cylinder(axis=Z, base_centre=(0um, 0um, 0um), radius=0.024um, height=0.03um)
  Au_anelc.unite(Au_disco)
  Air_Domain [vacuum] = box(corner=(-0.16um, -0.16um, -1um), size=(0.32um, 0.32um, 2.03um))
  Au_anelc_1 = Au_anelc.copy()
  Air_Domain.subtract(Au_anelc_1)
boundaries and excitations:
  LatticePair_R640DZ: Lattice Pair Faces=Air_Domain.face(-x, +x) CoordSysVector{(-0.16, -0.16, -1) -> (-0.16, -0.16, 1.03)} PhaseDelay=UseScanAngle Phi=0deg Theta=theta_inc
  LatticePair_AEWNVB: Lattice Pair Faces=Air_Domain.face(-y, +y) CoordSysVector{(0.16, -0.16, -1) -> (0.16, -0.16, 1.03)} PhaseDelay=UseScanAngle Phi=0deg Theta=theta_inc
  FloquetCima: Floquet Port Faces=Air_Domain.face(+z) NumModes=4 Modes{Mode1{CharImp=Zpi} Mode2{CharImp=Zpi} Mode3{CharImp=Zpi} Mode4{CharImp=Zpi}} PhaseDelay=UseScanAngle Phi=0deg Theta=theta_inc LatticeAVector{(-0.16, -0.16, 1.03) -> (0.16, -0.16, 1.03)} LatticeBVector{(-0.16, -0.16, 1.03) -> (-0.16, 0.16, 1.03)} ModesCalculator{Frequency=1GHz PhiStart=0deg PhiStop=0deg PhiStep=0deg ThetaStart=0deg ThetaStop=0deg ThetaStep=0deg} ModesList{Mode{ModeNumber=1 IndexM=0 IndexN=0 KC2=0 PropagationState=Undefined Attenuation=0 PolarizationState=TE AffectsRefinement} Mode{ModeNumber=2 IndexM=0 IndexN=0 KC2=0 PropagationState=Undefined Attenuation=0 PolarizationState=TM AffectsRefinement} Mode{ModeNumber=3 IndexM=-1 IndexN=0 KC2=385531421917553 PropagationState=Undefined Attenuation=1.7054704e+08 PolarizationState=TE AffectsRefinement} Mode{ModeNumber=4 IndexM=0 IndexN=-1 KC2=385531421917553 PropagationState=Undefined Attenuation=1.7054704e+08 PolarizationState=TE AffectsRefinement}}
  FloquetBaixo: Floquet Port Faces=Air_Domain.face(-z) NumModes=4 Modes{Mode1{CharImp=Zpi} Mode2{CharImp=Zpi} Mode3{CharImp=Zpi} Mode4{CharImp=Zpi}} PhaseDelay=UseScanAngle Phi=0deg Theta=theta_inc LatticeAVector{(-0.16, -0.16, -1) -> (0.16, -0.16, -1)} LatticeBVector{(-0.16, -0.16, -1) -> (-0.16, 0.16, -1)} ModesCalculator{Frequency=1GHz PhiStart=0deg PhiStop=0deg PhiStep=0deg ThetaStart=0deg ThetaStop=0deg ThetaStep=0deg} ModesList{Mode{ModeNumber=1 IndexM=0 IndexN=0 KC2=0 PropagationState=Undefined Attenuation=0 PolarizationState=TE AffectsRefinement} Mode{ModeNumber=2 IndexM=0 IndexN=0 KC2=0 PropagationState=Undefined Attenuation=0 PolarizationState=TM AffectsRefinement} Mode{ModeNumber=3 IndexM=-1 IndexN=0 KC2=385531421917553 PropagationState=Undefined Attenuation=1.7054704e+08 PolarizationState=TE AffectsRefinement} Mode{ModeNumber=4 IndexM=0 IndexN=-1 KC2=385531421917553 PropagationState=Undefined Attenuation=1.7054704e+08 PolarizationState=TE AffectsRefinement}}
setups:
  Setup1: HfssDriven Frequency=666.2THz MaxDeltaS=0.01 MaximumPasses=15 MinimumPasses=1 MinimumConvergedPasses=1 PercentRefinement=30 BasisOrder=1 PortAccuracy=2 DrivenSolverType="Direct Solver"
    sweep Varredura: 187.4THz to 666.2THz, 401 points; Type=Interpolating InterpTolerance=0.5 InterpMaxSolns=250 PassivityErrorTolerance=0.0001
source amplitudes:
  FloquetCima:1: 1W 0deg
  FloquetCima:2, FloquetCima:3, FloquetCima:4, FloquetBaixo:1..FloquetBaixo:4: 0W 0deg

design G1796_anelC_disco (HFSS, HFSS Modal Network, model units um)
variables:
  theta_inc = 0deg
geometry:
  Au_anelc [Au_JC] = cylinder(axis=Z, base_centre=(0um, 0um, 0um), radius=0.109um, height=0.03um)
  Au_anelc_furo = cylinder(axis=Z, base_centre=(0um, 0um, 0um), radius=0.082um, height=0.03um)
  Au_anelc.subtract(Au_anelc_furo)
  Au_disco = cylinder(axis=Z, base_centre=(0um, 0um, 0um), radius=0.063um, height=0.03um)
  Au_anelc.unite(Au_disco)
  Air_Domain [vacuum] = box(corner=(-0.16um, -0.16um, -1um), size=(0.32um, 0.32um, 2.03um))
  Au_anelc_1 = Au_anelc.copy()
  Air_Domain.subtract(Au_anelc_1)
boundaries and excitations:
  LatticePair_FA51EO: Lattice Pair Faces=Air_Domain.face(-x, +x) CoordSysVector{(-0.16, -0.16, -1) -> (-0.16, -0.16, 1.03)} PhaseDelay=UseScanAngle Phi=0deg Theta=theta_inc
  LatticePair_LQE4DN: Lattice Pair Faces=Air_Domain.face(-y, +y) CoordSysVector{(0.16, -0.16, -1) -> (0.16, -0.16, 1.03)} PhaseDelay=UseScanAngle Phi=0deg Theta=theta_inc
  FloquetCima: Floquet Port Faces=Air_Domain.face(+z) NumModes=4 Modes{Mode1{CharImp=Zpi} Mode2{CharImp=Zpi} Mode3{CharImp=Zpi} Mode4{CharImp=Zpi}} PhaseDelay=UseScanAngle Phi=0deg Theta=theta_inc LatticeAVector{(-0.16, -0.16, 1.03) -> (0.16, -0.16, 1.03)} LatticeBVector{(-0.16, -0.16, 1.03) -> (-0.16, 0.16, 1.03)} ModesCalculator{Frequency=1GHz PhiStart=0deg PhiStop=0deg PhiStep=0deg ThetaStart=0deg ThetaStop=0deg ThetaStep=0deg} ModesList{Mode{ModeNumber=1 IndexM=0 IndexN=0 KC2=0 PropagationState=Undefined Attenuation=0 PolarizationState=TE AffectsRefinement} Mode{ModeNumber=2 IndexM=0 IndexN=0 KC2=0 PropagationState=Undefined Attenuation=0 PolarizationState=TM AffectsRefinement} Mode{ModeNumber=3 IndexM=-1 IndexN=0 KC2=385531421917553 PropagationState=Undefined Attenuation=1.7054704e+08 PolarizationState=TE AffectsRefinement} Mode{ModeNumber=4 IndexM=0 IndexN=-1 KC2=385531421917553 PropagationState=Undefined Attenuation=1.7054704e+08 PolarizationState=TE AffectsRefinement}}
  FloquetBaixo: Floquet Port Faces=Air_Domain.face(-z) NumModes=4 Modes{Mode1{CharImp=Zpi} Mode2{CharImp=Zpi} Mode3{CharImp=Zpi} Mode4{CharImp=Zpi}} PhaseDelay=UseScanAngle Phi=0deg Theta=theta_inc LatticeAVector{(-0.16, -0.16, -1) -> (0.16, -0.16, -1)} LatticeBVector{(-0.16, -0.16, -1) -> (-0.16, 0.16, -1)} ModesCalculator{Frequency=1GHz PhiStart=0deg PhiStop=0deg PhiStep=0deg ThetaStart=0deg ThetaStop=0deg ThetaStep=0deg} ModesList{Mode{ModeNumber=1 IndexM=0 IndexN=0 KC2=0 PropagationState=Undefined Attenuation=0 PolarizationState=TE AffectsRefinement} Mode{ModeNumber=2 IndexM=0 IndexN=0 KC2=0 PropagationState=Undefined Attenuation=0 PolarizationState=TM AffectsRefinement} Mode{ModeNumber=3 IndexM=-1 IndexN=0 KC2=385531421917553 PropagationState=Undefined Attenuation=1.7054704e+08 PolarizationState=TE AffectsRefinement} Mode{ModeNumber=4 IndexM=0 IndexN=-1 KC2=385531421917553 PropagationState=Undefined Attenuation=1.7054704e+08 PolarizationState=TE AffectsRefinement}}
setups:
  Setup1: HfssDriven Frequency=666.2THz MaxDeltaS=0.01 MaximumPasses=15 MinimumPasses=1 MinimumConvergedPasses=1 PercentRefinement=30 BasisOrder=1 PortAccuracy=2 DrivenSolverType="Direct Solver"
    sweep Varredura: 187.4THz to 666.2THz, 401 points; Type=Interpolating InterpTolerance=0.5 InterpMaxSolns=250 PassivityErrorTolerance=0.0001
source amplitudes:
  FloquetCima:1: 1W 0deg
  FloquetCima:2, FloquetCima:3, FloquetCima:4, FloquetBaixo:1..FloquetBaixo:4: 0W 0deg

design G1652_anelC_disco (HFSS, HFSS Modal Network, model units um)
variables:
  theta_inc = 0deg
geometry:
  Au_anelc [Au_JC] = cylinder(axis=Z, base_centre=(0um, 0um, 0um), radius=0.086um, height=0.03um)
  Au_anelc_furo = cylinder(axis=Z, base_centre=(0um, 0um, 0um), radius=0.053um, height=0.03um)
  Au_anelc.subtract(Au_anelc_furo)
  Au_disco = cylinder(axis=Z, base_centre=(0um, 0um, 0um), radius=0.023um, height=0.03um)
  Au_anelc.unite(Au_disco)
  Air_Domain [vacuum] = box(corner=(-0.16um, -0.16um, -1um), size=(0.32um, 0.32um, 2.03um))
  Au_anelc_1 = Au_anelc.copy()
  Air_Domain.subtract(Au_anelc_1)
boundaries and excitations:
  LatticePair_28F070: Lattice Pair Faces=Air_Domain.face(-x, +x) CoordSysVector{(-0.16, -0.16, -1) -> (-0.16, -0.16, 1.03)} PhaseDelay=UseScanAngle Phi=0deg Theta=theta_inc
  LatticePair_MYSJIM: Lattice Pair Faces=Air_Domain.face(-y, +y) CoordSysVector{(0.16, -0.16, -1) -> (0.16, -0.16, 1.03)} PhaseDelay=UseScanAngle Phi=0deg Theta=theta_inc
  FloquetCima: Floquet Port Faces=Air_Domain.face(+z) NumModes=4 Modes{Mode1{CharImp=Zpi} Mode2{CharImp=Zpi} Mode3{CharImp=Zpi} Mode4{CharImp=Zpi}} PhaseDelay=UseScanAngle Phi=0deg Theta=theta_inc LatticeAVector{(-0.16, -0.16, 1.03) -> (0.16, -0.16, 1.03)} LatticeBVector{(-0.16, -0.16, 1.03) -> (-0.16, 0.16, 1.03)} ModesCalculator{Frequency=1GHz PhiStart=0deg PhiStop=0deg PhiStep=0deg ThetaStart=0deg ThetaStop=0deg ThetaStep=0deg} ModesList{Mode{ModeNumber=1 IndexM=0 IndexN=0 KC2=0 PropagationState=Undefined Attenuation=0 PolarizationState=TE AffectsRefinement} Mode{ModeNumber=2 IndexM=0 IndexN=0 KC2=0 PropagationState=Undefined Attenuation=0 PolarizationState=TM AffectsRefinement} Mode{ModeNumber=3 IndexM=-1 IndexN=0 KC2=385531421917553 PropagationState=Undefined Attenuation=1.7054704e+08 PolarizationState=TE AffectsRefinement} Mode{ModeNumber=4 IndexM=0 IndexN=-1 KC2=385531421917553 PropagationState=Undefined Attenuation=1.7054704e+08 PolarizationState=TE AffectsRefinement}}
  FloquetBaixo: Floquet Port Faces=Air_Domain.face(-z) NumModes=4 Modes{Mode1{CharImp=Zpi} Mode2{CharImp=Zpi} Mode3{CharImp=Zpi} Mode4{CharImp=Zpi}} PhaseDelay=UseScanAngle Phi=0deg Theta=theta_inc LatticeAVector{(-0.16, -0.16, -1) -> (0.16, -0.16, -1)} LatticeBVector{(-0.16, -0.16, -1) -> (-0.16, 0.16, -1)} ModesCalculator{Frequency=1GHz PhiStart=0deg PhiStop=0deg PhiStep=0deg ThetaStart=0deg ThetaStop=0deg ThetaStep=0deg} ModesList{Mode{ModeNumber=1 IndexM=0 IndexN=0 KC2=0 PropagationState=Undefined Attenuation=0 PolarizationState=TE AffectsRefinement} Mode{ModeNumber=2 IndexM=0 IndexN=0 KC2=0 PropagationState=Undefined Attenuation=0 PolarizationState=TM AffectsRefinement} Mode{ModeNumber=3 IndexM=-1 IndexN=0 KC2=385531421917553 PropagationState=Undefined Attenuation=1.7054704e+08 PolarizationState=TE AffectsRefinement} Mode{ModeNumber=4 IndexM=0 IndexN=-1 KC2=385531421917553 PropagationState=Undefined Attenuation=1.7054704e+08 PolarizationState=TE AffectsRefinement}}
setups:
  Setup1: HfssDriven Frequency=666.2THz MaxDeltaS=0.01 MaximumPasses=15 MinimumPasses=1 MinimumConvergedPasses=1 PercentRefinement=30 BasisOrder=1 PortAccuracy=2 DrivenSolverType="Direct Solver"
    sweep Varredura: 187.4THz to 666.2THz, 401 points; Type=Interpolating InterpTolerance=0.5 InterpMaxSolns=250 PassivityErrorTolerance=0.0001
source amplitudes:
  FloquetCima:1: 1W 0deg
  FloquetCima:2, FloquetCima:3, FloquetCima:4, FloquetBaixo:1..FloquetBaixo:4: 0W 0deg

design G1623_anelC_disco (HFSS, HFSS Modal Network, model units um)
variables:
  theta_inc = 0deg
geometry:
  Au_anelc [Au_JC] = cylinder(axis=Z, base_centre=(0um, 0um, 0um), radius=0.119um, height=0.03um)
  Au_anelc_furo = cylinder(axis=Z, base_centre=(0um, 0um, 0um), radius=0.078um, height=0.03um)
  Au_anelc.subtract(Au_anelc_furo)
  Au_disco = cylinder(axis=Z, base_centre=(0um, 0um, 0um), radius=0.049um, height=0.03um)
  Au_anelc.unite(Au_disco)
  Air_Domain [vacuum] = box(corner=(-0.16um, -0.16um, -1um), size=(0.32um, 0.32um, 2.03um))
  Au_anelc_1 = Au_anelc.copy()
  Air_Domain.subtract(Au_anelc_1)
boundaries and excitations:
  LatticePair_B9BPGV: Lattice Pair Faces=Air_Domain.face(-x, +x) CoordSysVector{(-0.16, -0.16, -1) -> (-0.16, -0.16, 1.03)} PhaseDelay=UseScanAngle Phi=0deg Theta=theta_inc
  LatticePair_K1W8IH: Lattice Pair Faces=Air_Domain.face(-y, +y) CoordSysVector{(0.16, -0.16, -1) -> (0.16, -0.16, 1.03)} PhaseDelay=UseScanAngle Phi=0deg Theta=theta_inc
  FloquetCima: Floquet Port Faces=Air_Domain.face(+z) NumModes=4 Modes{Mode1{CharImp=Zpi} Mode2{CharImp=Zpi} Mode3{CharImp=Zpi} Mode4{CharImp=Zpi}} PhaseDelay=UseScanAngle Phi=0deg Theta=theta_inc LatticeAVector{(-0.16, -0.16, 1.03) -> (0.16, -0.16, 1.03)} LatticeBVector{(-0.16, -0.16, 1.03) -> (-0.16, 0.16, 1.03)} ModesCalculator{Frequency=1GHz PhiStart=0deg PhiStop=0deg PhiStep=0deg ThetaStart=0deg ThetaStop=0deg ThetaStep=0deg} ModesList{Mode{ModeNumber=1 IndexM=0 IndexN=0 KC2=0 PropagationState=Undefined Attenuation=0 PolarizationState=TE AffectsRefinement} Mode{ModeNumber=2 IndexM=0 IndexN=0 KC2=0 PropagationState=Undefined Attenuation=0 PolarizationState=TM AffectsRefinement} Mode{ModeNumber=3 IndexM=-1 IndexN=0 KC2=385531421917553 PropagationState=Undefined Attenuation=1.7054704e+08 PolarizationState=TE AffectsRefinement} Mode{ModeNumber=4 IndexM=0 IndexN=-1 KC2=385531421917553 PropagationState=Undefined Attenuation=1.7054704e+08 PolarizationState=TE AffectsRefinement}}
  FloquetBaixo: Floquet Port Faces=Air_Domain.face(-z) NumModes=4 Modes{Mode1{CharImp=Zpi} Mode2{CharImp=Zpi} Mode3{CharImp=Zpi} Mode4{CharImp=Zpi}} PhaseDelay=UseScanAngle Phi=0deg Theta=theta_inc LatticeAVector{(-0.16, -0.16, -1) -> (0.16, -0.16, -1)} LatticeBVector{(-0.16, -0.16, -1) -> (-0.16, 0.16, -1)} ModesCalculator{Frequency=1GHz PhiStart=0deg PhiStop=0deg PhiStep=0deg ThetaStart=0deg ThetaStop=0deg ThetaStep=0deg} ModesList{Mode{ModeNumber=1 IndexM=0 IndexN=0 KC2=0 PropagationState=Undefined Attenuation=0 PolarizationState=TE AffectsRefinement} Mode{ModeNumber=2 IndexM=0 IndexN=0 KC2=0 PropagationState=Undefined Attenuation=0 PolarizationState=TM AffectsRefinement} Mode{ModeNumber=3 IndexM=-1 IndexN=0 KC2=385531421917553 PropagationState=Undefined Attenuation=1.7054704e+08 PolarizationState=TE AffectsRefinement} Mode{ModeNumber=4 IndexM=0 IndexN=-1 KC2=385531421917553 PropagationState=Undefined Attenuation=1.7054704e+08 PolarizationState=TE AffectsRefinement}}
setups:
  Setup1: HfssDriven Frequency=666.2THz MaxDeltaS=0.01 MaximumPasses=15 MinimumPasses=1 MinimumConvergedPasses=1 PercentRefinement=30 BasisOrder=1 PortAccuracy=2 DrivenSolverType="Direct Solver"
    sweep Varredura: 187.4THz to 666.2THz, 401 points; Type=Interpolating InterpTolerance=0.5 InterpMaxSolns=250 PassivityErrorTolerance=0.0001
source amplitudes:
  FloquetCima:1: 1W 0deg
  FloquetCima:2, FloquetCima:3, FloquetCima:4, FloquetBaixo:1..FloquetBaixo:4: 0W 0deg

design G1794_anelC_disco (HFSS, HFSS Modal Network, model units um)
variables:
  theta_inc = 0deg
geometry:
  Au_anelc [Au_JC] = cylinder(axis=Z, base_centre=(0um, 0um, 0um), radius=0.1um, height=0.03um)
  Au_anelc_furo = cylinder(axis=Z, base_centre=(0um, 0um, 0um), radius=0.079um, height=0.03um)
  Au_anelc.subtract(Au_anelc_furo)
  Au_disco = cylinder(axis=Z, base_centre=(0um, 0um, 0um), radius=0.022um, height=0.03um)
  Au_anelc.unite(Au_disco)
  Air_Domain [vacuum] = box(corner=(-0.16um, -0.16um, -1um), size=(0.32um, 0.32um, 2.03um))
  Au_anelc_1 = Au_anelc.copy()
  Air_Domain.subtract(Au_anelc_1)
boundaries and excitations:
  LatticePair_L67XL8: Lattice Pair Faces=Air_Domain.face(-x, +x) CoordSysVector{(-0.16, -0.16, -1) -> (-0.16, -0.16, 1.03)} PhaseDelay=UseScanAngle Phi=0deg Theta=theta_inc
  LatticePair_SZ8VEJ: Lattice Pair Faces=Air_Domain.face(-y, +y) CoordSysVector{(0.16, -0.16, -1) -> (0.16, -0.16, 1.03)} PhaseDelay=UseScanAngle Phi=0deg Theta=theta_inc
  FloquetCima: Floquet Port Faces=Air_Domain.face(+z) NumModes=4 Modes{Mode1{CharImp=Zpi} Mode2{CharImp=Zpi} Mode3{CharImp=Zpi} Mode4{CharImp=Zpi}} PhaseDelay=UseScanAngle Phi=0deg Theta=theta_inc LatticeAVector{(-0.16, -0.16, 1.03) -> (0.16, -0.16, 1.03)} LatticeBVector{(-0.16, -0.16, 1.03) -> (-0.16, 0.16, 1.03)} ModesCalculator{Frequency=1GHz PhiStart=0deg PhiStop=0deg PhiStep=0deg ThetaStart=0deg ThetaStop=0deg ThetaStep=0deg} ModesList{Mode{ModeNumber=1 IndexM=0 IndexN=0 KC2=0 PropagationState=Undefined Attenuation=0 PolarizationState=TE AffectsRefinement} Mode{ModeNumber=2 IndexM=0 IndexN=0 KC2=0 PropagationState=Undefined Attenuation=0 PolarizationState=TM AffectsRefinement} Mode{ModeNumber=3 IndexM=-1 IndexN=0 KC2=385531421917553 PropagationState=Undefined Attenuation=1.7054704e+08 PolarizationState=TE AffectsRefinement} Mode{ModeNumber=4 IndexM=0 IndexN=-1 KC2=385531421917553 PropagationState=Undefined Attenuation=1.7054704e+08 PolarizationState=TE AffectsRefinement}}
  FloquetBaixo: Floquet Port Faces=Air_Domain.face(-z) NumModes=4 Modes{Mode1{CharImp=Zpi} Mode2{CharImp=Zpi} Mode3{CharImp=Zpi} Mode4{CharImp=Zpi}} PhaseDelay=UseScanAngle Phi=0deg Theta=theta_inc LatticeAVector{(-0.16, -0.16, -1) -> (0.16, -0.16, -1)} LatticeBVector{(-0.16, -0.16, -1) -> (-0.16, 0.16, -1)} ModesCalculator{Frequency=1GHz PhiStart=0deg PhiStop=0deg PhiStep=0deg ThetaStart=0deg ThetaStop=0deg ThetaStep=0deg} ModesList{Mode{ModeNumber=1 IndexM=0 IndexN=0 KC2=0 PropagationState=Undefined Attenuation=0 PolarizationState=TE AffectsRefinement} Mode{ModeNumber=2 IndexM=0 IndexN=0 KC2=0 PropagationState=Undefined Attenuation=0 PolarizationState=TM AffectsRefinement} Mode{ModeNumber=3 IndexM=-1 IndexN=0 KC2=385531421917553 PropagationState=Undefined Attenuation=1.7054704e+08 PolarizationState=TE AffectsRefinement} Mode{ModeNumber=4 IndexM=0 IndexN=-1 KC2=385531421917553 PropagationState=Undefined Attenuation=1.7054704e+08 PolarizationState=TE AffectsRefinement}}
setups:
  Setup1: HfssDriven Frequency=666.2THz MaxDeltaS=0.01 MaximumPasses=15 MinimumPasses=1 MinimumConvergedPasses=1 PercentRefinement=30 BasisOrder=1 PortAccuracy=2 DrivenSolverType="Direct Solver"
    sweep Varredura: 187.4THz to 666.2THz, 401 points; Type=Interpolating InterpTolerance=0.5 InterpMaxSolns=250 PassivityErrorTolerance=0.0001
source amplitudes:
  FloquetCima:1: 1W 0deg
  FloquetCima:2, FloquetCima:3, FloquetCima:4, FloquetBaixo:1..FloquetBaixo:4: 0W 0deg

design G1682_anelC_disco (HFSS, HFSS Modal Network, model units um)
variables:
  theta_inc = 0deg
geometry:
  Au_anelc [Au_JC] = cylinder(axis=Z, base_centre=(0um, 0um, 0um), radius=0.111um, height=0.03um)
  Au_anelc_furo = cylinder(axis=Z, base_centre=(0um, 0um, 0um), radius=0.084um, height=0.03um)
  Au_anelc.subtract(Au_anelc_furo)
  Au_disco = cylinder(axis=Z, base_centre=(0um, 0um, 0um), radius=0.046um, height=0.03um)
  Au_anelc.unite(Au_disco)
  Air_Domain [vacuum] = box(corner=(-0.16um, -0.16um, -1um), size=(0.32um, 0.32um, 2.03um))
  Au_anelc_1 = Au_anelc.copy()
  Air_Domain.subtract(Au_anelc_1)
boundaries and excitations:
  LatticePair_B8KGMZ: Lattice Pair Faces=Air_Domain.face(-x, +x) CoordSysVector{(-0.16, -0.16, -1) -> (-0.16, -0.16, 1.03)} PhaseDelay=UseScanAngle Phi=0deg Theta=theta_inc
  LatticePair_QWNUMM: Lattice Pair Faces=Air_Domain.face(-y, +y) CoordSysVector{(0.16, -0.16, -1) -> (0.16, -0.16, 1.03)} PhaseDelay=UseScanAngle Phi=0deg Theta=theta_inc
  FloquetCima: Floquet Port Faces=Air_Domain.face(+z) NumModes=4 Modes{Mode1{CharImp=Zpi} Mode2{CharImp=Zpi} Mode3{CharImp=Zpi} Mode4{CharImp=Zpi}} PhaseDelay=UseScanAngle Phi=0deg Theta=theta_inc LatticeAVector{(-0.16, -0.16, 1.03) -> (0.16, -0.16, 1.03)} LatticeBVector{(-0.16, -0.16, 1.03) -> (-0.16, 0.16, 1.03)} ModesCalculator{Frequency=1GHz PhiStart=0deg PhiStop=0deg PhiStep=0deg ThetaStart=0deg ThetaStop=0deg ThetaStep=0deg} ModesList{Mode{ModeNumber=1 IndexM=0 IndexN=0 KC2=0 PropagationState=Undefined Attenuation=0 PolarizationState=TE AffectsRefinement} Mode{ModeNumber=2 IndexM=0 IndexN=0 KC2=0 PropagationState=Undefined Attenuation=0 PolarizationState=TM AffectsRefinement} Mode{ModeNumber=3 IndexM=-1 IndexN=0 KC2=385531421917553 PropagationState=Undefined Attenuation=1.7054704e+08 PolarizationState=TE AffectsRefinement} Mode{ModeNumber=4 IndexM=0 IndexN=-1 KC2=385531421917553 PropagationState=Undefined Attenuation=1.7054704e+08 PolarizationState=TE AffectsRefinement}}
  FloquetBaixo: Floquet Port Faces=Air_Domain.face(-z) NumModes=4 Modes{Mode1{CharImp=Zpi} Mode2{CharImp=Zpi} Mode3{CharImp=Zpi} Mode4{CharImp=Zpi}} PhaseDelay=UseScanAngle Phi=0deg Theta=theta_inc LatticeAVector{(-0.16, -0.16, -1) -> (0.16, -0.16, -1)} LatticeBVector{(-0.16, -0.16, -1) -> (-0.16, 0.16, -1)} ModesCalculator{Frequency=1GHz PhiStart=0deg PhiStop=0deg PhiStep=0deg ThetaStart=0deg ThetaStop=0deg ThetaStep=0deg} ModesList{Mode{ModeNumber=1 IndexM=0 IndexN=0 KC2=0 PropagationState=Undefined Attenuation=0 PolarizationState=TE AffectsRefinement} Mode{ModeNumber=2 IndexM=0 IndexN=0 KC2=0 PropagationState=Undefined Attenuation=0 PolarizationState=TM AffectsRefinement} Mode{ModeNumber=3 IndexM=-1 IndexN=0 KC2=385531421917553 PropagationState=Undefined Attenuation=1.7054704e+08 PolarizationState=TE AffectsRefinement} Mode{ModeNumber=4 IndexM=0 IndexN=-1 KC2=385531421917553 PropagationState=Undefined Attenuation=1.7054704e+08 PolarizationState=TE AffectsRefinement}}
setups:
  Setup1: HfssDriven Frequency=666.2THz MaxDeltaS=0.01 MaximumPasses=15 MinimumPasses=1 MinimumConvergedPasses=1 PercentRefinement=30 BasisOrder=1 PortAccuracy=2 DrivenSolverType="Direct Solver"
    sweep Varredura: 187.4THz to 666.2THz, 401 points; Type=Interpolating InterpTolerance=0.5 InterpMaxSolns=250 PassivityErrorTolerance=0.0001
source amplitudes:
  FloquetCima:1: 1W 0deg
  FloquetCima:2, FloquetCima:3, FloquetCima:4, FloquetBaixo:1..FloquetBaixo:4: 0W 0deg

design G1807_anelC_disco_trilhas (HFSS, HFSS Modal Network, model units um)
variables:
  theta_inc = 0deg
geometry:
  Au_anelc [Au_JC] = cylinder(axis=Z, base_centre=(0um, 0um, 0um), radius=0.133um, height=0.03um)
  Au_anelc_furo = cylinder(axis=Z, base_centre=(0um, 0um, 0um), radius=0.101um, height=0.03um)
  Au_anelc.subtract(Au_anelc_furo)
  Au_disco = cylinder(axis=Z, base_centre=(0um, 0um, 0um), radius=0.047um, height=0.03um)
  Au_trilha0 = box(corner=(0.037um, -0.013um, 0um), size=(0.08um, 0.026um, 0.03um))
  Au_trilha1 = box(corner=(-0.117um, -0.013um, 0um), size=(0.08um, 0.026um, 0.03um))
  Au_trilha2 = box(corner=(-0.013um, 0.037um, 0um), size=(0.026um, 0.08um, 0.03um))
  Au_trilha3 = box(corner=(-0.013um, -0.117um, 0um), size=(0.026um, 0.08um, 0.03um))
  Au_anelc.unite(Au_disco, Au_trilha0..Au_trilha3)
  Air_Domain [vacuum] = box(corner=(-0.16um, -0.16um, -1um), size=(0.32um, 0.32um, 2.03um))
  Au_anelc_1 = Au_anelc.copy()
  Air_Domain.subtract(Au_anelc_1)
boundaries and excitations:
  LatticePair_FKFYHS: Lattice Pair Faces=Air_Domain.face(-x, +x) CoordSysVector{(-0.16, -0.16, -1) -> (-0.16, -0.16, 1.03)} PhaseDelay=UseScanAngle Phi=0deg Theta=theta_inc
  LatticePair_0DBZM4: Lattice Pair Faces=Air_Domain.face(-y, +y) CoordSysVector{(0.16, -0.16, -1) -> (0.16, -0.16, 1.03)} PhaseDelay=UseScanAngle Phi=0deg Theta=theta_inc
  FloquetCima: Floquet Port Faces=Air_Domain.face(+z) NumModes=4 Modes{Mode1{CharImp=Zpi} Mode2{CharImp=Zpi} Mode3{CharImp=Zpi} Mode4{CharImp=Zpi}} PhaseDelay=UseScanAngle Phi=0deg Theta=theta_inc LatticeAVector{(-0.16, -0.16, 1.03) -> (0.16, -0.16, 1.03)} LatticeBVector{(-0.16, -0.16, 1.03) -> (-0.16, 0.16, 1.03)} ModesCalculator{Frequency=1GHz PhiStart=0deg PhiStop=0deg PhiStep=0deg ThetaStart=0deg ThetaStop=0deg ThetaStep=0deg} ModesList{Mode{ModeNumber=1 IndexM=0 IndexN=0 KC2=0 PropagationState=Undefined Attenuation=0 PolarizationState=TE AffectsRefinement} Mode{ModeNumber=2 IndexM=0 IndexN=0 KC2=0 PropagationState=Undefined Attenuation=0 PolarizationState=TM AffectsRefinement} Mode{ModeNumber=3 IndexM=-1 IndexN=0 KC2=385531421917553 PropagationState=Undefined Attenuation=1.7054704e+08 PolarizationState=TE AffectsRefinement} Mode{ModeNumber=4 IndexM=0 IndexN=-1 KC2=385531421917553 PropagationState=Undefined Attenuation=1.7054704e+08 PolarizationState=TE AffectsRefinement}}
  FloquetBaixo: Floquet Port Faces=Air_Domain.face(-z) NumModes=4 Modes{Mode1{CharImp=Zpi} Mode2{CharImp=Zpi} Mode3{CharImp=Zpi} Mode4{CharImp=Zpi}} PhaseDelay=UseScanAngle Phi=0deg Theta=theta_inc LatticeAVector{(-0.16, -0.16, -1) -> (0.16, -0.16, -1)} LatticeBVector{(-0.16, -0.16, -1) -> (-0.16, 0.16, -1)} ModesCalculator{Frequency=1GHz PhiStart=0deg PhiStop=0deg PhiStep=0deg ThetaStart=0deg ThetaStop=0deg ThetaStep=0deg} ModesList{Mode{ModeNumber=1 IndexM=0 IndexN=0 KC2=0 PropagationState=Undefined Attenuation=0 PolarizationState=TE AffectsRefinement} Mode{ModeNumber=2 IndexM=0 IndexN=0 KC2=0 PropagationState=Undefined Attenuation=0 PolarizationState=TM AffectsRefinement} Mode{ModeNumber=3 IndexM=-1 IndexN=0 KC2=385531421917553 PropagationState=Undefined Attenuation=1.7054704e+08 PolarizationState=TE AffectsRefinement} Mode{ModeNumber=4 IndexM=0 IndexN=-1 KC2=385531421917553 PropagationState=Undefined Attenuation=1.7054704e+08 PolarizationState=TE AffectsRefinement}}
setups:
  Setup1: HfssDriven Frequency=666.2THz MaxDeltaS=0.01 MaximumPasses=15 MinimumPasses=1 MinimumConvergedPasses=1 PercentRefinement=30 BasisOrder=1 PortAccuracy=2 DrivenSolverType="Direct Solver"
    sweep Varredura: 187.4THz to 666.2THz, 401 points; Type=Interpolating InterpTolerance=0.5 InterpMaxSolns=250 PassivityErrorTolerance=0.0001
source amplitudes:
  FloquetCima:1: 1W 0deg
  FloquetCima:2, FloquetCima:3, FloquetCima:4, FloquetBaixo:1..FloquetBaixo:4: 0W 0deg

design G1972_anelC_disco_trilhas (HFSS, HFSS Modal Network, model units um)
variables:
  theta_inc = 0deg
geometry:
  Au_anelc [Au_JC] = cylinder(axis=Z, base_centre=(0um, 0um, 0um), radius=0.103um, height=0.03um)
  Au_anelc_furo = cylinder(axis=Z, base_centre=(0um, 0um, 0um), radius=0.064um, height=0.03um)
  Au_anelc.subtract(Au_anelc_furo)
  Au_disco = cylinder(axis=Z, base_centre=(0um, 0um, 0um), radius=0.051um, height=0.03um)
  Au_trilha0 = box(corner=(0.041um, -0.0145um, 0um), size=(0.0425um, 0.029um, 0.03um))
  Au_trilha1 = box(corner=(-0.0835um, -0.0145um, 0um), size=(0.0425um, 0.029um, 0.03um))
  Au_trilha2 = box(corner=(-0.0145um, 0.041um, 0um), size=(0.029um, 0.0425um, 0.03um))
  Au_trilha3 = box(corner=(-0.0145um, -0.0835um, 0um), size=(0.029um, 0.0425um, 0.03um))
  Au_anelc.unite(Au_disco, Au_trilha0..Au_trilha3)
  Air_Domain [vacuum] = box(corner=(-0.16um, -0.16um, -1um), size=(0.32um, 0.32um, 2.03um))
  Au_anelc_1 = Au_anelc.copy()
  Air_Domain.subtract(Au_anelc_1)
boundaries and excitations:
  LatticePair_YAZPJM: Lattice Pair Faces=Air_Domain.face(-x, +x) CoordSysVector{(-0.16, -0.16, -1) -> (-0.16, -0.16, 1.03)} PhaseDelay=UseScanAngle Phi=0deg Theta=theta_inc
  LatticePair_T7ODYX: Lattice Pair Faces=Air_Domain.face(-y, +y) CoordSysVector{(0.16, -0.16, -1) -> (0.16, -0.16, 1.03)} PhaseDelay=UseScanAngle Phi=0deg Theta=theta_inc
  FloquetCima: Floquet Port Faces=Air_Domain.face(+z) NumModes=4 Modes{Mode1{CharImp=Zpi} Mode2{CharImp=Zpi} Mode3{CharImp=Zpi} Mode4{CharImp=Zpi}} PhaseDelay=UseScanAngle Phi=0deg Theta=theta_inc LatticeAVector{(-0.16, -0.16, 1.03) -> (0.16, -0.16, 1.03)} LatticeBVector{(-0.16, -0.16, 1.03) -> (-0.16, 0.16, 1.03)} ModesCalculator{Frequency=1GHz PhiStart=0deg PhiStop=0deg PhiStep=0deg ThetaStart=0deg ThetaStop=0deg ThetaStep=0deg} ModesList{Mode{ModeNumber=1 IndexM=0 IndexN=0 KC2=0 PropagationState=Undefined Attenuation=0 PolarizationState=TE AffectsRefinement} Mode{ModeNumber=2 IndexM=0 IndexN=0 KC2=0 PropagationState=Undefined Attenuation=0 PolarizationState=TM AffectsRefinement} Mode{ModeNumber=3 IndexM=-1 IndexN=0 KC2=385531421917553 PropagationState=Undefined Attenuation=1.7054704e+08 PolarizationState=TE AffectsRefinement} Mode{ModeNumber=4 IndexM=0 IndexN=-1 KC2=385531421917553 PropagationState=Undefined Attenuation=1.7054704e+08 PolarizationState=TE AffectsRefinement}}
  FloquetBaixo: Floquet Port Faces=Air_Domain.face(-z) NumModes=4 Modes{Mode1{CharImp=Zpi} Mode2{CharImp=Zpi} Mode3{CharImp=Zpi} Mode4{CharImp=Zpi}} PhaseDelay=UseScanAngle Phi=0deg Theta=theta_inc LatticeAVector{(-0.16, -0.16, -1) -> (0.16, -0.16, -1)} LatticeBVector{(-0.16, -0.16, -1) -> (-0.16, 0.16, -1)} ModesCalculator{Frequency=1GHz PhiStart=0deg PhiStop=0deg PhiStep=0deg ThetaStart=0deg ThetaStop=0deg ThetaStep=0deg} ModesList{Mode{ModeNumber=1 IndexM=0 IndexN=0 KC2=0 PropagationState=Undefined Attenuation=0 PolarizationState=TE AffectsRefinement} Mode{ModeNumber=2 IndexM=0 IndexN=0 KC2=0 PropagationState=Undefined Attenuation=0 PolarizationState=TM AffectsRefinement} Mode{ModeNumber=3 IndexM=-1 IndexN=0 KC2=385531421917553 PropagationState=Undefined Attenuation=1.7054704e+08 PolarizationState=TE AffectsRefinement} Mode{ModeNumber=4 IndexM=0 IndexN=-1 KC2=385531421917553 PropagationState=Undefined Attenuation=1.7054704e+08 PolarizationState=TE AffectsRefinement}}
setups:
  Setup1: HfssDriven Frequency=666.2THz MaxDeltaS=0.01 MaximumPasses=15 MinimumPasses=1 MinimumConvergedPasses=1 PercentRefinement=30 BasisOrder=1 PortAccuracy=2 DrivenSolverType="Direct Solver"
    sweep Varredura: 187.4THz to 666.2THz, 401 points; Type=Interpolating InterpTolerance=0.5 InterpMaxSolns=250 PassivityErrorTolerance=0.0001
source amplitudes:
  FloquetCima:1: 1W 0deg
  FloquetCima:2, FloquetCima:3, FloquetCima:4, FloquetBaixo:1..FloquetBaixo:4: 0W 0deg

design G1869_anelC_disco_trilhas (HFSS, HFSS Modal Network, model units um)
variables:
  theta_inc = 0deg
geometry:
  Au_anelc [Au_JC] = cylinder(axis=Z, base_centre=(0um, 0um, 0um), radius=0.136um, height=0.03um)
  Au_anelc_furo = cylinder(axis=Z, base_centre=(0um, 0um, 0um), radius=0.094um, height=0.03um)
  Au_anelc.subtract(Au_anelc_furo)
  Au_disco = cylinder(axis=Z, base_centre=(0um, 0um, 0um), radius=0.029um, height=0.03um)
  Au_trilha0 = box(corner=(0.019um, -0.0085um, 0um), size=(0.096um, 0.017um, 0.03um))
  Au_trilha1 = box(corner=(-0.115um, -0.0085um, 0um), size=(0.096um, 0.017um, 0.03um))
  Au_trilha2 = box(corner=(-0.0085um, 0.019um, 0um), size=(0.017um, 0.096um, 0.03um))
  Au_trilha3 = box(corner=(-0.0085um, -0.115um, 0um), size=(0.017um, 0.096um, 0.03um))
  Au_anelc.unite(Au_disco, Au_trilha0..Au_trilha3)
  Air_Domain [vacuum] = box(corner=(-0.16um, -0.16um, -1um), size=(0.32um, 0.32um, 2.03um))
  Au_anelc_1 = Au_anelc.copy()
  Air_Domain.subtract(Au_anelc_1)
boundaries and excitations:
  LatticePair_BN9WJY: Lattice Pair Faces=Air_Domain.face(-x, +x) CoordSysVector{(-0.16, -0.16, -1) -> (-0.16, -0.16, 1.03)} PhaseDelay=UseScanAngle Phi=0deg Theta=theta_inc
  LatticePair_EBK48M: Lattice Pair Faces=Air_Domain.face(-y, +y) CoordSysVector{(0.16, -0.16, -1) -> (0.16, -0.16, 1.03)} PhaseDelay=UseScanAngle Phi=0deg Theta=theta_inc
  FloquetCima: Floquet Port Faces=Air_Domain.face(+z) NumModes=4 Modes{Mode1{CharImp=Zpi} Mode2{CharImp=Zpi} Mode3{CharImp=Zpi} Mode4{CharImp=Zpi}} PhaseDelay=UseScanAngle Phi=0deg Theta=theta_inc LatticeAVector{(-0.16, -0.16, 1.03) -> (0.16, -0.16, 1.03)} LatticeBVector{(-0.16, -0.16, 1.03) -> (-0.16, 0.16, 1.03)} ModesCalculator{Frequency=1GHz PhiStart=0deg PhiStop=0deg PhiStep=0deg ThetaStart=0deg ThetaStop=0deg ThetaStep=0deg} ModesList{Mode{ModeNumber=1 IndexM=0 IndexN=0 KC2=0 PropagationState=Undefined Attenuation=0 PolarizationState=TE AffectsRefinement} Mode{ModeNumber=2 IndexM=0 IndexN=0 KC2=0 PropagationState=Undefined Attenuation=0 PolarizationState=TM AffectsRefinement} Mode{ModeNumber=3 IndexM=-1 IndexN=0 KC2=385531421917553 PropagationState=Undefined Attenuation=1.7054704e+08 PolarizationState=TE AffectsRefinement} Mode{ModeNumber=4 IndexM=0 IndexN=-1 KC2=385531421917553 PropagationState=Undefined Attenuation=1.7054704e+08 PolarizationState=TE AffectsRefinement}}
  FloquetBaixo: Floquet Port Faces=Air_Domain.face(-z) NumModes=4 Modes{Mode1{CharImp=Zpi} Mode2{CharImp=Zpi} Mode3{CharImp=Zpi} Mode4{CharImp=Zpi}} PhaseDelay=UseScanAngle Phi=0deg Theta=theta_inc LatticeAVector{(-0.16, -0.16, -1) -> (0.16, -0.16, -1)} LatticeBVector{(-0.16, -0.16, -1) -> (-0.16, 0.16, -1)} ModesCalculator{Frequency=1GHz PhiStart=0deg PhiStop=0deg PhiStep=0deg ThetaStart=0deg ThetaStop=0deg ThetaStep=0deg} ModesList{Mode{ModeNumber=1 IndexM=0 IndexN=0 KC2=0 PropagationState=Undefined Attenuation=0 PolarizationState=TE AffectsRefinement} Mode{ModeNumber=2 IndexM=0 IndexN=0 KC2=0 PropagationState=Undefined Attenuation=0 PolarizationState=TM AffectsRefinement} Mode{ModeNumber=3 IndexM=-1 IndexN=0 KC2=385531421917553 PropagationState=Undefined Attenuation=1.7054704e+08 PolarizationState=TE AffectsRefinement} Mode{ModeNumber=4 IndexM=0 IndexN=-1 KC2=385531421917553 PropagationState=Undefined Attenuation=1.7054704e+08 PolarizationState=TE AffectsRefinement}}
setups:
  Setup1: HfssDriven Frequency=666.2THz MaxDeltaS=0.01 MaximumPasses=15 MinimumPasses=1 MinimumConvergedPasses=1 PercentRefinement=30 BasisOrder=1 PortAccuracy=2 DrivenSolverType="Direct Solver"
    sweep Varredura: 187.4THz to 666.2THz, 401 points; Type=Interpolating InterpTolerance=0.5 InterpMaxSolns=250 PassivityErrorTolerance=0.0001
source amplitudes:
  FloquetCima:1: 1W 0deg
  FloquetCima:2, FloquetCima:3, FloquetCima:4, FloquetBaixo:1..FloquetBaixo:4: 0W 0deg

design G1959_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